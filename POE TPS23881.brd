# Allegro board POE TPS23881.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN2 (solid shape): 97.99,31.7 97.99,28.22 97.94,28.17 94.46,28.17 94.39,28.24 94.39,31.7 94.49,31.8 97.89,31.8
GND on IN2 (solid shape): 105.79,25.53 105.79,22 105.66,21.87 102.08,21.87 101.83,22.12 101.83,25.53 101.96,25.65 105.66,25.65
GND on IN2 (solid shape): 116.28,31.37 116.28,28.22 116.23,28.17 112.75,28.17 112.67,28.24 112.67,31.37 112.8,31.5 116.15,31.5
GND on IN2 (solid shape): 124.08,25.53 124.08,22 123.95,21.87 120.37,21.87 120.12,22.12 120.12,25.53 120.24,25.65 123.95,25.65
GND on IN2 (solid shape): 132.74,50.42 132.74,47.24 132.61,47.12 129.57,47.12 129.44,47.24 129.44,50.42 129.57,50.55 132.61,50.55
GND on IN2 (solid shape): 134.57,32.08 134.57,28.6 134.52,28.55 131.04,28.55 130.96,28.63 130.96,32.08 131.06,32.18 134.47,32.18
GND on IN2 (solid shape): 136.04,60.07 136.04,57.15 135.92,57.02 132.11,57.02 131.98,57.15 131.98,60.07 132.11,60.2 135.92,60.2
GND on IN2 (solid shape): 22.07,199.49 22.07,198.98 1.02,198.98 1.02,16.92 0.51,16.92 0.51,199.49 22.05,199.49
GND on IN2 (solid shape): 47.45,70.18 47.45,68.28 47.19,68.02 45.54,68.02 44.78,68.78 42.62,68.78 41.99,69.42 41.99,71.96 42.62,72.59 45.03,72.59
GND on IN2 (solid shape): 72.8,111.76 72.8,109.22 72.54,108.97 69.11,108.97 68.86,109.22 68.86,111.63 69.49,112.27 72.29,112.27
GND on IN2 (solid shape): 94.89,97.03 94.89,95.28 93.85,94.23 93.09,94.23 92.6,93.74 89.8,93.74 89.69,93.85 89.69,96.9 90.58,97.79 94.13,97.79
GND on IN2 (solid shape): 96.42,68.45 96.42,65.28 95.78,64.64 93.37,64.64 93.24,64.77 93.24,68.58 93.37,68.71 96.16,68.71
GND on IN2 (solid shape): 159.49,58.7 158.98,58.7 158.98,181.2 159.05,181.27 159.05,183.44 158.67,183.83 158.67,185.06 158.98,185.37 158.98,198.98 103.17,198.98 103.17,199.49 159.49,199.49
GND on IN2 (solid shape): 142.37,25.81 142.37,22 142.24,21.87 138.66,21.87 138.2,22.33 138.2,24.82 138.79,25.4 139.47,25.4 139.98,25.91 142.27,25.91
GND on IN2 (solid shape): outline of 476 points within 1.37,14.52 31.17,35.61
GND on IN2 (solid shape): outline of 1077 points within 104.6,14.52 132.16,35.43
GND on IN2 (solid shape): outline of 1239 points within 51.31,14.52 71.48,33.43
GND on IN2 (solid shape): outline of 1273 points within 87.19,14.52 111.05,35.28
GND on IN2 (solid shape): outline of 1496 points within 68.49,14.52 91.16,35.53
GND on IN2 (solid shape): outline of 2095 points within 14.23,14.52 52.22,36.32
GND on IN2 (solid shape): outline of 7070 points within 36.5,14.52 153.16,57.61
GND on IN3 (solid shape): 22.1,198.98 1.02,198.98 1.02,16.89 0.51,16.89 0.51,199.49 22.1,199.49
GND on IN3 (solid shape): 50.93,25.53 50.93,22 50.8,21.87 47.22,21.87 46.96,22.12 46.96,25.53 47.09,25.65 50.8,25.65
GND on IN3 (solid shape): 69.22,25.53 69.22,22 69.09,21.87 65.51,21.87 65.25,22.12 65.25,25.53 65.38,25.65 69.09,25.65
GND on IN3 (solid shape): 75.64,158.19 75.64,154.38 74.88,153.62 71.58,153.62 70.82,154.38 70.82,158.7 71.07,158.95 74.88,158.95
GND on IN3 (solid shape): 87.5,25.53 87.5,22 87.38,21.87 83.79,21.87 83.54,22.12 83.54,25.53 83.67,25.65 87.38,25.65
GND on IN3 (solid shape): 105.79,25.53 105.79,22 105.66,21.87 102.08,21.87 101.83,22.12 101.83,25.53 101.96,25.65 105.66,25.65
GND on IN3 (solid shape): 124.08,25.53 124.08,22 123.95,21.87 120.37,21.87 120.12,22.12 120.12,25.53 120.24,25.65 123.95,25.65
GND on IN3 (solid shape): 47.45,70.18 47.45,68.28 47.19,68.02 45.54,68.02 44.78,68.78 42.62,68.78 41.99,69.42 41.99,71.96 42.62,72.59 45.03,72.59
GND on IN3 (solid shape): 72.8,111.76 72.8,109.22 72.54,108.97 69.11,108.97 68.86,109.22 68.86,111.63 69.49,112.27 72.29,112.27
GND on IN3 (solid shape): 96.42,68.45 96.42,65.28 95.78,64.64 93.37,64.64 93.24,64.77 93.24,68.58 93.37,68.71 96.16,68.71
GND on IN3 (solid shape): 159.49,58.7 158.98,58.7 158.98,181.84 159.05,181.91 159.05,183.36 158.72,183.69 158.72,185.77 158.98,186.03 158.98,198.98 103.14,198.98 103.14,199.49 159.49,199.49
GND on IN3 (solid shape): 141.5,83.69 141.5,81.66 141.38,81.53 134.65,81.53 133.5,80.39 127.79,80.39 127.66,80.52 127.66,82.42 127.79,82.55 133.63,82.55 134.01,82.93 134.01,84.2 134.14,84.33 140.87,84.33
GND on IN3 (solid shape): 142.39,25.91 142.39,25.55 142.37,25.53 142.37,22 142.24,21.87 138.43,21.87 138.2,22.1 138.2,24.82 138.46,25.07 138.46,25.91 138.58,26.04 142.27,26.04
GND on IN3 (solid shape): 149.86,95.86 149.86,93.45 149.63,93.22 146.08,93.22 145.69,93.6 145.69,94.77 144.91,95.55 143.87,95.55 143.81,95.61 143.81,95.89 143.87,95.94 144.48,95.94 144.55,96.01 149.71,96.01
GND on IN3 (solid shape): outline of 821 points within 1.38,156.69 31.17,198.65
GND on IN3 (solid shape): outline of 951 points within 136.12,153.72 158.57,190.42
GND on TOP: 129.84,26.49 136.86,26.49 137.06,26.7 137.06,29.77 136.35,30.48 136.35,32.89 137.29,33.83 137.29,34.42 137.21,34.49 128.88,34.49 128.37,33.99 128.37,26.09 128.45,26.01 129.36,26.01
GND on TOP: 3.61,17.02 3.48,16.89 1.7,16.89 1.57,17.02 1.57,19.13 1.73,19.28 3.45,19.28 3.61,19.13
GND on TOP: 21.64,29.03 28.65,29.03 28.85,29.24 28.85,32.31 28.14,33.02 28.14,35.43 29.03,36.32 29.03,36.96 28.98,37.01 20.65,37.01 20.17,36.53 20.17,28.82 20.4,28.59 21.2,28.59
GND on TOP: 22.1,58.29 23.11,58.29 23.24,58.17 23.24,56.64 23.37,56.52 24,56.52 24.13,56.64 24.13,58.17 24.26,58.29 25.27,58.29 25.4,58.17 25.4,55.98 25.3,55.88 21.72,55.88 21.62,55.98 21.62,57.81
GND on TOP: 101.96,25.65 105.49,25.65 105.79,25.35 105.79,22 105.66,21.87 102.08,21.87 101.83,22.12 101.83,25.53
GND on TOP: 24.13,45.09 25.27,45.09 25.4,44.96 25.4,42.8 25.27,42.67 21.97,42.67 21.84,42.8 21.84,44.96 21.97,45.09 22.99,45.09 23.11,44.96 23.11,43.56 23.24,43.43 23.88,43.43 24,43.56 24,44.96
GND on TOP: 138.46,98.4 138.46,102.44 138.33,102.57 131.65,102.57 131.47,102.39 131.47,100.05 133.25,98.27 138.33,98.27
GND on TOP: 25.68,16.76 27.33,16.76 27.46,16.64 27.46,14.48 27.33,14.35 25.55,14.35 25.43,14.48 25.43,16.51
GND on TOP: 126.44,35.66 126.44,35.23 126.39,35.18 124.79,35.18 124.69,35.28 124.69,37.11 124.74,37.16 125.02,37.16 125.04,37.13 125.04,35.86 125.15,35.76 126.34,35.76
GND on TOP: 70.31,53.95 71.7,53.95 72.19,54.43 73.99,54.43 74.12,54.31 74.12,53.29 74.03,53.2 70.31,53.2 70.18,53.33 70.18,53.82
GND on TOP: 86.87,169.16 125.86,169.16 125.98,169.04 125.98,167.51 125.86,167.39 86.87,167.39 86.74,167.51 86.74,169.04
GND on TOP: 142.14,107.57 142.14,106.78 141.97,106.62 138.34,106.62 138.28,106.68 138.28,107.49 138.51,107.72 141.99,107.72
GND on TOP: 38.18,120.47 35.38,120.47 35.26,120.6 35.26,124.28 35.38,124.41 38.3,124.41 38.43,124.28 38.43,120.73
GND on TOP: 125.78,42.47 126.21,42.47 126.26,42.42 126.26,40.82 126.16,40.72 124.33,40.72 124.28,40.77 124.28,41.05 124.31,41.07 125.58,41.07 125.68,41.17 125.68,42.37
GND on TOP: 151.66,143.31 152.98,143.31 153.06,143.23 153.06,141.68 152.93,141.55 151.69,141.55 151.59,141.66 151.59,143.23
GND on TOP: 29.54,116.92 35,116.92 35.26,116.66 35.26,100.15 35,99.9 29.79,99.9 29.16,100.53 29.16,116.54
GND on TOP: 49.89,98.45 51.08,98.45 51.26,98.63 51.26,100.36 51.73,100.83 51.73,102.73 51.66,102.79 49.94,102.79 49.76,102.62 49.76,98.58
GND on TOP: 147.52,12.85 158.14,12.85 158.45,13.16 158.45,34.7 157.96,35.18 155.24,35.18 153.16,37.26 153.16,40.97 152.65,41.48 150.88,41.48 149,39.6 145.16,39.6 143.48,37.92 143.48,30.68 144.22,29.95 144.22,20.62 143.81,20.22 133.17,20.22 132.92,19.96 132.92,18.29 133.12,18.08 145.64,18.08 146.74,16.99 146.74,13.64
GND on TOP: 82.3,181.86 84.2,181.86 84.33,181.74 84.33,179.96 84.2,179.83 82.3,179.83 82.17,179.96 82.17,181.74
GND on TOP: 127.15,89.28 131.6,89.28 131.98,88.9 131.98,83.57 132.99,82.55 133.63,82.55 134.14,83.06 134.14,84.2 134.26,84.33 137.57,84.33 137.95,83.95 141.38,83.95 141.5,83.82 141.5,81.66 141.38,81.53 134.57,81.53 133.3,80.26 127.15,80.26 127.03,80.39 127.03,89.15
GND on TOP: 41.35,91.14 41.48,91.01 41.48,88.85 41.35,88.72 38.81,88.72 38.68,88.85 38.68,91.01 38.81,91.14
GND on TOP: 55.12,174.24 59.31,174.24 59.44,174.12 59.44,172.59 59.31,172.47 55.12,172.47 54.99,172.59 54.99,174.12
GND on TOP: 139.98,103.5 142.14,103.5 142.27,103.63 142.27,105.36 142.11,105.51 139.98,105.51 139.85,105.38 139.85,103.63
GND on TOP: 116.99,92.96 123.34,92.96 123.85,93.47 123.85,100.33 123.98,100.46 125.25,100.46 125.37,100.33 125.37,91.31 124.61,90.55 116.99,90.55 116.87,90.68 116.87,92.84
GND on TOP: 23.14,197.87 23.39,197.61 23.39,193.04 23.27,192.91 22.63,192.91 22.38,192.66 22.38,191.52 22.12,191.26 18.69,191.26 18.57,191.39 18.57,197.49 18.95,197.87
GND on TOP: 133.12,93.22 138.46,93.22 138.58,93.09 138.58,91.44 138.46,91.31 133.12,91.31 132.99,91.44 132.99,93.09
GND on TOP: 47.09,25.65 50.62,25.65 50.93,25.35 50.93,22 50.8,21.87 47.57,21.87 46.96,22.48 46.96,25.53
GND on TOP: 58.52,103.68 65.07,103.68 65.2,103.56 65.2,102.01 65.1,101.9 58.88,101.9 58.8,101.98 58.8,102.92 58.47,103.25 58.47,103.63
GND on TOP: 97.87,60.27 103.2,60.27 103.33,60.15 103.33,57.61 103.2,57.48 97.74,57.48 97.61,57.61 97.61,60.02
GND on TOP: 38.3,173.3 43.26,173.3 43.38,173.18 43.38,167.72 43.26,167.59 38.3,167.59 38.05,167.84 38.05,173.05
GND on TOP: outline of 125 points within 56.34,90.02 69.8,101.12
GND on TOP: 7.11,45.09 8.13,45.09 8.26,44.96 8.26,43.43 8.38,43.31 9.02,43.31 9.14,43.43 9.14,44.96 9.27,45.09 10.29,45.09 10.41,44.96 10.41,42.42 10.29,42.29 6.99,42.29 6.86,42.42 6.86,44.83
GND on TOP: 75.36,91.59 75.44,91.52 75.44,88.93 75.34,88.82 74.57,88.82 74.5,88.9 74.5,91.54 74.55,91.59
GND on TOP: 132.72,60.2 135.38,60.2 136.14,59.44 136.14,57.02 136.02,56.9 132.21,56.9 131.95,57.15 131.95,59.44
GND on TOP: 65.38,25.65 68.91,25.65 69.22,25.35 69.22,22 69.09,21.87 65.51,21.87 65.25,22.12 65.25,25.53
GND on TOP: 117.22,131.44 119.51,131.44 119.63,131.32 119.63,128.91 119.51,128.78 117.22,128.78 117.09,128.91 117.09,131.32
GND on TOP: 150.01,96.01 150.14,95.89 150.14,93.47 149.89,93.22 145.82,93.22 145.57,93.47 145.57,95.89 145.69,96.01
GND on TOP: 108.15,35.28 108.15,34.85 108.1,34.8 106.5,34.8 106.4,34.9 106.4,36.73 106.45,36.78 106.73,36.78 106.76,36.75 106.76,35.48 106.86,35.38 108.05,35.38
GND on TOP: 89.87,35.31 89.87,34.87 89.81,34.82 88.21,34.82 88.11,34.92 88.11,36.75 88.16,36.8 88.44,36.8 88.47,36.78 88.47,35.51 88.57,35.41 89.76,35.41
GND on TOP: 108.79,49.81 110.13,49.81 110.26,49.68 110.26,48.46 110.13,48.34 108.81,48.34 108.71,48.44 108.71,49.73
GND on TOP: 82.45,97.41 84.61,97.41 84.73,97.28 84.73,95.12 84.61,95 83.08,95 82.32,95.76 82.32,97.28
GND on TOP: 115.21,101.09 116.51,101.09 116.61,100.99 116.61,98.37 116.36,98.12 115.19,98.12 115.01,98.3 115.01,100.89
GND on TOP: 39.57,181.81 41.99,181.81 42.11,181.69 42.11,178.51 41.86,178.26 39.57,178.26 39.45,178.38 39.45,181.69
GND on TOP: 150.75,185.67 154.18,185.67 154.43,185.93 154.43,190.75 154.05,191.13 151.64,191.13 151.51,191.26 151.51,193.55 150.62,194.44 147.57,194.44 147.45,194.56 147.45,197.36 147.83,197.74 156.46,197.74 156.97,197.23 156.97,175.77 156.72,175.51 151.89,175.51 151.51,175.9 151.51,181.1 151.26,181.36 150.62,181.36 150.5,181.48 150.5,185.42
GND on TOP: 56.69,26.11 63.7,26.11 63.91,26.31 63.91,29.39 63.2,30.1 63.2,32.51 64.14,33.45 64.14,34.04 64.06,34.11 55.73,34.11 55.22,33.6 55.22,25.7 55.3,25.63 56.21,25.63
GND on TOP: 138.53,26.04 142.06,26.04 142.37,25.73 142.37,22.38 142.24,22.25 138.66,22.25 138.4,22.5 138.4,25.91
GND on TOP: 44.65,96.09 48.21,96.09 48.46,95.83 48.46,93.93 48.34,93.8 44.78,93.8 44.65,93.68 43.89,93.68 43.76,93.8 43.76,94.31 43.89,94.44 44.4,94.44 44.53,94.56 44.53,95.96
GND on TOP: 147.98,64.39 149.5,64.39 149.63,64.26 149.63,62.87 149.5,62.74 147.98,62.74 147.85,62.87 147.85,64.26
GND on TOP: 42.55,129.92 44.07,129.92 44.2,129.79 44.2,127 44.07,126.87 42.55,126.87 42.42,127 42.42,129.79
GND on TOP: 125.22,178.82 127.89,178.82 128.02,178.69 128.02,177.16 127.89,177.04 125.22,177.04 125.09,177.16 125.09,178.69
GND on TOP: 111.56,26.11 118.57,26.11 118.77,26.31 118.77,29.39 118.06,30.1 118.06,32.51 119,33.45 119,34.04 118.92,34.11 110.59,34.11 110.08,33.6 110.08,25.7 110.16,25.63 111.07,25.63
GND on TOP: 38.4,26.11 45.42,26.11 45.62,26.31 45.62,29.39 44.91,30.1 44.91,32.51 45.85,33.45 45.85,34.04 45.77,34.11 37.44,34.11 36.93,33.6 36.93,25.7 37.01,25.63 37.92,25.63
GND on TOP: 74.98,26.11 81.99,26.11 82.19,26.31 82.19,29.39 81.48,30.1 81.48,32.51 82.42,33.45 82.42,34.04 82.35,34.11 74.02,34.11 73.51,33.6 73.51,25.7 73.58,25.63 74.5,25.63
GND on TOP: 18.8,119.71 18.8,124.46 18.92,124.59 21.08,124.59 21.21,124.46 21.21,119.76 21.03,119.58 18.92,119.58
GND on TOP: 7.11,58.29 8.13,58.29 8.26,58.17 8.26,56.64 8.38,56.52 9.02,56.52 9.14,56.64 9.14,58.17 9.27,58.29 10.29,58.29 10.41,58.17 10.41,55.93 10.33,55.84 7.1,55.84 6.86,56.08 6.86,58.04
GND on TOP: 93.27,26.11 100.28,26.11 100.48,26.31 100.48,29.39 99.77,30.1 99.77,32.51 100.71,33.45 100.71,34.04 100.63,34.11 92.3,34.11 91.8,33.6 91.8,25.7 91.87,25.63 92.79,25.63
GND on TOP: 18.24,38.23 18.24,37.8 18.19,37.74 16.59,37.74 16.48,37.85 16.48,39.67 16.54,39.73 16.81,39.73 16.84,39.7 16.84,38.43 16.94,38.33 18.14,38.33
GND on TOP: 35,35.31 35,34.87 34.95,34.82 33.35,34.82 33.25,34.92 33.25,36.75 33.3,36.8 33.58,36.8 33.6,36.78 33.6,35.51 33.71,35.41 34.9,35.41
GND on TOP: 4.62,183.18 4.52,183.08 1.35,183.08 1.24,183.18 1.24,186.61 1.4,186.77 4.52,186.77 4.62,186.66
GND on TOP: 30.33,28.57 33.86,28.57 34.16,28.27 34.16,24.92 34.04,24.79 30.45,24.79 30.2,25.04 30.2,28.45
GND on TOP: 133.35,130.68 136.02,130.68 136.53,130.18 148.97,130.18 149.1,130.05 149.1,129.29 148.84,129.03 146.18,129.03 145.92,128.78 136.25,128.78 136.25,128.88 135.76,129.36 135.48,129.36 134.98,129.87 134.7,129.87 134.65,129.82 133.58,129.82 133.22,130.18 133.22,130.56
GND on TOP: 133.1,144.55 133.83,144.55 133.96,144.68 133.96,146.74 134.72,147.5 134.72,151.46 134.67,151.51 133.91,151.51 133.02,150.62 133.02,144.63
GND on TOP: 77.09,174.37 78.84,174.37 78.99,174.22 78.99,171.7 78.74,171.45 70.03,171.45 69.85,171.63 69.85,172.9 70.15,173.2 75.92,173.2
GND on TOP: 23.62,184.66 25.27,184.66 25.4,184.53 25.4,178.56 25.27,178.44 24.64,178.44 23.5,179.58 23.5,184.53
GND on TOP: 117.37,87.25 119.41,87.25 119.53,87.12 119.53,80.39 119.41,80.26 117.37,80.26 117.25,80.39 117.25,87.12
GND on TOP: 71.58,35.31 71.58,34.87 71.53,34.82 69.93,34.82 69.82,34.92 69.82,36.75 69.88,36.8 70.15,36.8 70.18,36.78 70.18,35.51 70.28,35.41 71.48,35.41
GND on TOP: 141.25,147.32 142.37,147.32 142.62,147.57 142.62,149.73 142.37,149.99 141.22,149.99 141.1,150.11 141.1,151.38 141.22,151.51 143.76,151.51 143.89,151.38 143.89,146.81 143.51,146.43 143.51,142.75 143.27,142.51 139.43,142.51 139.19,142.75 139.19,143.28 138.96,143.51 138.96,148.29 139.14,148.46 140.87,148.46 141,148.34 141,147.57
GND on TOP: 75.41,97.31 76.86,97.31 76.99,97.18 76.99,94.69 76.89,94.59 75.44,94.59 75.34,94.69 75.34,97.23
GND on TOP: 44.65,105.74 48.21,105.74 48.46,105.49 48.46,103.58 48.34,103.45 44.78,103.45 44.65,103.33 43.89,103.33 43.76,103.45 43.76,103.96 43.89,104.09 44.4,104.09 44.53,104.22 44.53,105.61
GND on TOP: 53.29,35.31 53.29,34.87 53.24,34.82 51.64,34.82 51.54,34.92 51.54,36.75 51.59,36.8 51.87,36.8 51.89,36.78 51.89,35.51 51.99,35.41 53.19,35.41
GND on TOP: 36.96,157.23 37.08,157.1 37.08,153.54 36.96,153.42 33.27,153.42 33.02,153.67 33.02,156.97 33.27,157.23
GND on TOP: 83.67,25.65 87.2,25.65 87.5,25.35 87.5,22 87.38,21.87 83.79,21.87 83.54,22.12 83.54,25.53
GND on TOP: 120.24,25.65 123.77,25.65 124.08,25.35 124.08,22 123.95,21.87 120.37,21.87 120.12,22.12 120.12,25.53
GND on TOP: 23.24,156.84 22.99,156.59 11.68,156.59 11.3,156.97 11.3,164.21 12.95,165.86 22.86,165.86 23.24,165.48
GND on TOP: 68.15,181.66 70.82,181.66 70.89,181.58 70.89,179.35 70.69,179.15 68.2,179.15 67.87,179.48 67.87,181.38
GND on TOP: 41.48,100.62 41.48,98.5 41.35,98.37 38.81,98.37 38.68,98.5 38.68,100.53 38.87,100.72 41.38,100.72
GND on TOP: 150.85,41.48 152.63,41.48 152.76,41.35 152.76,39.4 152.6,39.24 150.98,39.24 150.77,39.45 150.77,41.4
GND on BOTTOM: 69.93,35.36 71.3,35.36 71.53,35.13 71.53,33.91 71.48,33.86 69.82,33.86 69.77,33.91 69.77,35.2
GND on BOTTOM: 88.21,35.36 89.59,35.36 89.81,35.13 89.81,33.91 89.76,33.86 88.11,33.86 88.06,33.91 88.06,35.2
GND on BOTTOM: 144.55,96.01 150.01,96.01 150.14,95.89 150.14,93.47 149.89,93.22 146.08,93.22 145.69,93.6 145.69,94.77 144.91,95.55 143.87,95.55 143.81,95.61 143.81,95.89 143.87,95.94 144.48,95.94
GND on BOTTOM: 87.5,97.49 88.8,97.49 88.87,97.41 88.87,95.4 88.75,95.28 87.55,95.28 87.45,95.38 87.45,97.43
GND on BOTTOM: 82.5,182.32 84.18,182.32 84.33,182.17 84.33,179.96 84.2,179.83 82.45,179.83 82.3,179.98 82.3,182.12
GND on BOTTOM: 23.09,198.02 23.22,197.89 23.22,196.47 22.25,195.5 22.25,191.39 22.12,191.26 18.82,191.26 18.57,191.52 18.57,197.61 18.97,198.02
GND on BOTTOM: 149.76,64.26 149.76,62.87 149.63,62.74 147.85,62.74 147.73,62.87 147.73,64.26 147.85,64.39 149.63,64.39
GND on BOTTOM: 83.64,53.92 86.64,53.92 87.2,53.37 87.2,52.27 86.94,52.02 82.12,52.02 81.99,52.15 81.99,53.16 82.12,53.29 82.37,53.29 82.5,53.16 83.39,53.16 83.52,53.29 83.52,53.8
GND on BOTTOM: 106.5,35.36 107.87,35.36 108.1,35.13 108.1,33.91 108.05,33.86 106.4,33.86 106.35,33.91 106.35,35.2
GND on BOTTOM: 39.01,91.26 41.35,91.26 41.45,91.16 41.45,88.57 41.33,88.44 38.94,88.44 38.79,88.6 38.79,91.03
GND on BOTTOM: 39.09,100.94 41.3,100.94 41.43,100.81 41.43,98.3 41.27,98.15 38.89,98.15 38.73,98.3 38.73,100.58
GND on BOTTOM: 1.42,186.84 4.52,186.84 4.7,186.66 4.7,183.18 4.47,182.96 1.37,182.96 1.22,183.11 1.22,186.64
GND on BOTTOM: 25.4,179.45 25.27,179.32 23.9,179.32 23.65,179.58 23.65,184.53 23.77,184.66 25.27,184.66 25.4,184.53
GND on BOTTOM: 108.48,88.01 111.4,88.01 111.53,87.88 111.53,83.06 111.4,82.93 108.48,82.93 108.36,83.06 108.36,87.88
GND on BOTTOM: 13.67,60.91 15.7,60.91 15.82,60.78 15.82,59.13 15.7,59 13.67,59 13.54,59.13 13.54,60.78
GND on BOTTOM: 30.63,178.05 32.54,178.05 32.66,177.93 32.66,176.53 32.54,176.4 30.63,176.4 30.51,176.53 30.51,177.93
GND on BOTTOM: 151.36,120.02 156.49,120.02 156.69,119.81 156.69,115.49 156.21,115.01 152.93,115.01 152.63,115.32 152.63,117.3 151.23,118.69 151.23,119.89
GND on BOTTOM: 28.65,60.91 30.68,60.91 30.81,60.78 30.81,59.13 30.68,59 28.65,59 28.52,59.13 28.52,60.78
GND on BOTTOM: 11.63,129.36 11.76,129.24 11.76,127.18 11.07,126.49 11.07,124.71 10.95,124.59 10.19,124.59 10.06,124.71 10.06,129.16 10.26,129.36
GND on BOTTOM: 139.06,106.55 138.96,106.65 138.96,107.42 139.19,107.65 141.96,107.65 142.24,107.92 146,107.92 146.1,107.82 146.1,106.83 145.82,106.55
GND on BOTTOM: 33.35,35.36 34.72,35.36 34.95,35.13 34.95,33.91 34.9,33.86 33.25,33.86 33.2,33.91 33.2,35.2
GND on BOTTOM: 115.21,101.09 116.48,101.09 116.61,100.97 116.61,98.17 116.48,98.04 115.21,98.04 115.09,98.17 115.09,100.97
GND on BOTTOM: 68.33,182.5 68.83,182.5 69.6,181.74 70.74,181.74 70.87,181.61 70.87,180.09 69.72,178.94 68.45,178.94 67.82,179.58 67.82,181.99
GND on BOTTOM: 125.68,40.84 125.68,42.21 125.91,42.44 127.13,42.44 127.18,42.39 127.18,40.74 127.13,40.69 125.83,40.69
GND on BOTTOM: 22.3,123.9 22.3,117.3 22.17,117.17 19.91,117.17 18.39,115.65 17.35,115.65 17.09,115.9 17.09,119.56 17.17,119.63 18.69,119.63 18.95,119.89 18.95,130.63 19.2,130.89 21.54,130.89 21.74,130.68 21.74,124.46
GND on BOTTOM: 12.83,181.36 13.84,181.36 13.97,181.23 13.97,178.69 13.84,178.56 12.83,178.56 12.7,178.69 12.7,181.23
GND on BOTTOM: 16.59,38.28 17.96,38.28 18.19,38.05 18.19,36.83 18.14,36.78 16.48,36.78 16.43,36.83 16.43,38.13
GND on BOTTOM: 6.17,60.91 8.2,60.91 8.33,60.78 8.33,59.13 8.2,59 6.17,59 6.05,59.13 6.05,60.78
GND on BOTTOM: 64.06,147.68 67.21,147.68 67.34,147.55 67.34,143.36 67.59,143.1 69.55,143.1 69.65,143 69.65,138.71 69.39,138.46 64.06,138.46 63.88,138.63 63.88,147.5
GND on BOTTOM: 45.42,105.74 48.21,105.74 48.46,105.49 48.46,103.58 48.34,103.45 45.42,103.45 45.29,103.58 45.29,105.61
GND on BOTTOM: 50.24,150.19 52.91,150.19 53.04,150.06 53.04,146.25 52.91,146.13 51.89,146.13 51.64,145.87 51.64,144.22 51.51,144.09 50.11,144.09 49.99,144.22 49.99,145.62 49.73,145.87 49.73,148.29 50.11,148.67 50.11,150.06
GND on BOTTOM: 124.05,97.05 125.3,97.05 125.43,97.18 125.43,100.36 125.32,100.46 123.98,100.46 123.88,100.36 123.88,97.23
GND on BOTTOM: 45.42,96.09 48.21,96.09 48.46,95.83 48.46,93.93 48.34,93.8 45.42,93.8 45.29,93.93 45.29,95.96
GND on BOTTOM: 28.52,47.7 30.56,47.7 30.68,47.57 30.68,45.92 30.56,45.8 28.52,45.8 28.4,45.92 28.4,47.57
GND on BOTTOM: 98.7,85.6 98.7,89.15 98.58,89.28 93.5,89.28 92.99,89.79 92.99,90.04 92.61,90.42 91.85,90.42 91.72,90.3 91.72,85.72 91.95,85.5 91.95,82.19 92,82.14 92.56,82.14 92.84,82.42 96.55,82.42 96.93,82.8 98.07,82.8 98.26,82.99 98.26,84.98 98.32,85.04 98.32,85.22
GND on BOTTOM: 51.64,35.36 53.01,35.36 53.24,35.13 53.24,33.91 53.19,33.86 51.54,33.86 51.49,33.91 51.49,35.2
GND on BOTTOM: 124.79,35.74 126.16,35.74 126.39,35.51 126.39,34.29 126.34,34.24 124.69,34.24 124.64,34.29 124.64,35.59
GND on BOTTOM: 134.14,84.33 140.87,84.33 141.5,83.69 141.5,81.66 141.38,81.53 134.65,81.53 133.5,80.39 127.79,80.39 127.66,80.52 127.66,82.42 127.79,82.55 133.63,82.55 134.01,82.93 134.01,84.2
GND on BOTTOM: 120.02,170.81 124.97,170.81 125.35,170.43 125.35,167 125.09,166.75 118.62,166.75 118.36,167 118.36,169.16
GND on BOTTOM: 13.97,80.44 17.04,80.44 17.25,80.24 17.25,70.41 17.02,70.18 13.79,70.18 13.67,70.31 13.67,72.52 13.44,72.75 11.38,72.75 11.18,72.95 11.18,79.22 11.38,79.43 12.95,79.43
GND on BOTTOM: 37.03,173.3 43.13,173.3 45.92,170.51 63.58,170.51 64.34,169.75 64.34,165.81 64.08,165.56 51.64,165.56 51.13,165.05 51.13,158.45 51.51,158.06 60.4,158.06 60.66,157.81 60.66,154.89 60.27,154.51 42.75,154.51 40.59,152.35 33.35,152.35 33.1,152.6 33.1,156.92 33.35,157.18 36.4,157.18 36.78,157.56 36.78,173.05
GND on BOTTOM: 83.11,95 82.41,95.69 82.41,97.7 82.5,97.79 83.92,97.79 84.02,97.89 84.02,98.27 84.07,98.32 84.68,98.32 84.73,98.27 84.73,95.12 84.61,95
GND on BOTTOM: 101.75,84.33 102.9,84.33 103.02,84.2 103.02,79.88 102.9,79.76 101.63,79.76 101.5,79.88 101.5,80.77 101.63,80.9 101.63,84.2
GND on GND1: 103.12,199.49 159.49,199.49 159.49,58.67 153.88,58.67 149.97,62.59 149.8,62.7 149.61,62.74 145.03,62.74 144.84,62.7 144.67,62.59 143.91,61.83 143.8,61.66 143.76,61.47 143.76,42.29 143.8,42.1 143.91,41.93 144.67,41.17 144.84,41.06 145.03,41.02 149.99,41.02 150.18,41.06 150.35,41.17 150.71,41.53 152.57,41.53 153.16,40.94 153.16,18.5 153.08,18.41 148.97,18.41 148.78,18.38 148.61,18.27 147.72,17.38 147.61,17.21 147.57,17.02 147.57,15.83 145.71,13.97 9.86,13.97 7.09,16.74 6.93,16.85 6.73,16.89 0.51,16.89 0.51,199.49 22.1,199.49 22.1,198.88 22.1,198.83 22.1,189.61 22.19,189.12 22.47,188.71 26.28,184.9 26.69,184.63 27.18,184.53 33.64,184.53 36.19,181.98 36.6,181.71 37.08,181.61 41.13,181.61 41.77,180.97 42.19,180.69 42.67,180.59 62.48,180.59 62.97,180.69 63.38,180.97 63.9,181.48 92.08,181.48 92.56,181.58 92.97,181.85 102.75,191.63 103.03,192.05 103.12,192.53 ; 1 cut-out
GND on IN1: 110.97,163.45 111.63,163.45 112.27,164.08 112.27,164.72 114.3,166.75 114.3,169.8 112.27,171.83 112.27,172.72 112.65,173.1 112.65,174.12 111.12,175.64 88.77,175.64 87.88,174.75 87.88,163.83 87.95,163.77 87.95,157.72 89,156.67 102.26,156.67 108.86,163.27 110.79,163.27
GND on IN1: 83.03,153.11 83.21,152.93 83.21,148.41 82.98,148.18 81.28,148.18 81.13,148.34 81.13,153.09 81.15,153.11
GND on IN1: 84.23,58.32 84.23,51.31 84,51.08 81.13,51.08 79.73,52.48 79.73,58.17 80.04,58.47 84.07,58.47
GND on IN1: 53.06,80.47 55.4,80.47 56.69,79.17 57.3,79.17 57.73,78.74 57.73,76.45 59.13,75.06 59.13,74.7 59.21,74.63 59.21,73.71 59.05,73.56 53.95,73.56 52.68,74.83 52.68,80.09
GND on IN1: 42.62,72.59 45.03,72.59 47.45,70.18 47.45,68.28 47.19,68.02 45.54,68.02 44.78,68.78 42.62,68.78 41.99,69.42 41.99,71.96
GND on IN1: 33.5,69.34 35.03,70.87 35.03,83.01 37.01,84.99 46.58,84.99 48.46,86.87 48.46,88.11 47.27,88.11 46.69,88.7 46.69,90.93 46.38,91.24 46.38,91.57 47.42,92.61 48.46,92.61 48.46,97.46 48.26,97.66 48.26,97.71 48.18,97.79 46.48,97.79 46.2,98.07 46.2,101.02 46.41,101.22 48.46,101.22 48.46,139.37 47.45,140.39 38.79,140.39 36.55,138.15 36.55,118.39 35.41,117.25 30.15,117.25 26.54,113.64 26.54,99.92 24.28,97.66 24.28,75.49 25.86,73.91 25.86,69.9 26.42,69.34
GND on IN1: 96.16,68.71 96.42,68.45 96.42,65.28 95.78,64.64 93.37,64.64 93.24,64.77 93.24,68.58 93.37,68.71
GND on IN1: 71.07,158.95 74.88,158.95 75.64,158.19 75.64,154.38 74.88,153.62 71.58,153.62 70.82,154.38 70.82,158.7
GND on IN1: 103.38,198.63 142.42,198.63 143.21,197.84 143.21,185.83 139.12,181.74 97.66,181.74 96.72,182.68 96.72,185.55 103.15,191.97 103.15,198.4
GND on IN1: 79.1,97.79 81.25,99.95 81.25,103.84 80.16,104.93 77.11,104.93 76.78,105.26 76.78,106.43 76.63,106.58 75.26,106.58 74.96,106.27 74.96,97.99 75.16,97.79
GND on IN1: 136.93,122.3 152.04,122.3 152.3,122.05 152.3,116.71 152.27,116.69 152.27,116.38 152.04,116.15 136.55,116.15 136.42,116.28 136.42,121.79
GND on IN1: 86.11,75.62 86.11,72.39 85.65,71.93 85.65,67.54 85.32,67.21 79.45,67.21 79.25,67.41 79.25,68.2 77.57,69.88 77.57,76.02 78.23,76.68 85.04,76.68
GND on IN1: 38.29,43.5 39.37,42.42 53.59,42.42 61.85,34.16 67.06,34.16 68.07,35.18 77.22,35.18 77.72,34.67 84.71,34.67 86.36,33.02 95.12,33.02 96.27,31.88 107.42,31.88 107.89,32.35 108.29,32.35 108.76,32.82 114.43,32.82 115.39,33.78 131.95,33.78 132.59,34.42 138.94,34.42 141.48,31.88 141.48,26.67 141.22,26.42 138.18,26.42 138.05,26.29 138.05,26.09 138.15,25.98 138.15,25.1 138.05,24.99 138.05,21.84 138.43,21.46 144.53,21.46 147.45,18.54 147.45,15.75 145.8,14.1 9.78,14.1 6.86,17.02 1.78,17.02 1.52,17.27 1.52,43.31 1.71,43.5 ; 6 cut-outs
GND on IN1: 30.48,28.57 33.91,28.57 34.16,28.32 34.16,24.77 34.04,24.64 30.73,24.64 30.23,25.15 30.23,28.32
GND on IN1: 98.09,68.68 107.57,68.68 110.59,71.7 112.29,71.7 113.06,70.94 113.06,61.75 109.73,58.42 105.71,58.42 104.65,57.35 98.09,57.35 97.38,58.06 97.38,67.97
GND on IN1: 107.57,56.13 113.13,56.13 115.01,58.01 122.35,58.01 122.91,57.45 122.91,52.68 118.72,48.49 109.19,48.49 107.11,50.57 107.11,55.68
GND on IN1: 50.11,144.35 52.91,144.35 56.69,148.13 66.01,148.13 67.23,149.35 67.23,164.36 63.55,168.05 54.84,168.05 49.53,173.35 36.55,173.35 36.14,172.95 36.14,159.97 32.94,156.77 32.94,152.98 36.83,149.1 36.83,144.25 38.38,142.7 43.1,142.7 44.45,144.04 44.45,150.22 45.24,151 48.92,151 49.1,151.18 49.1,151.69 49.28,151.87 50.14,151.87 50.32,151.69 50.32,150.06 48.97,148.72 48.97,145.49
GND on IN1: 99.69,76.15 99.68,76.14 99.68,75.48 97.03,72.82 91.69,72.82 91.01,73.51 91.01,79.58 92.1,80.67 92.61,80.67 92.86,80.92 92.86,81.71 92.43,82.14 92.43,83.46 92.53,83.57 98.65,83.57 99.69,82.52
GND on IN1: 100.46,91.95 98.17,89.66 98.17,89.41 98.04,89.28 93.34,89.28 92.58,90.04 92.58,93.22 93.09,93.73 94.23,93.73 96.01,95.5 100.08,95.5 100.46,95.12
GND on IN1: 90.58,97.79 94.13,97.79 94.89,97.03 94.89,94.84 94.09,94.04 92.8,94.04 92.35,93.6 89.94,93.6 89.69,93.85 89.69,96.9
GND on IN1: 71.36,133.39 69.9,131.93 69.9,130.4 70.05,130.25 72.34,130.25 72.95,130.86 73.76,130.86 74.32,131.42 74.32,132.23 75.51,133.43 75.51,134.95 75.9,135.33 93.9,135.33 99.19,130.05 99.19,117.75 98.93,117.5 96.7,117.5 96.32,117.88 96.32,121.06 96.57,121.31 96.57,121.67 96.24,122 95.15,122 94.74,121.59 94.74,121.39 95.02,121.11 95.02,117.75 94.77,117.5 87.96,117.5 85.29,120.17 85.29,120.24 82.78,120.24 81.94,121.08 80.21,121.08 79.68,120.55 79.68,119.2 79.86,119.02 79.86,116.66 79.43,116.23 74.78,116.23 74.22,116.79 74.22,120.57 74.85,121.21 74.85,122.58 74.57,122.86 74.57,125.83 73.51,126.9 72.14,126.9 71.81,126.57 71.81,126.01 72.01,125.81 73.28,125.81 73.74,125.35 73.74,123.04 72.52,121.82 72.52,120.73 72.85,120.4 72.85,119.41 72.01,118.57 72.01,116.51 71.73,116.23 66.34,116.23 64.73,117.84 64.73,126.15 62.36,128.52 60.88,128.52 60.71,128.35 59.79,128.35 58.6,129.54 58.6,133.53 59.36,134.29 71.13,134.29 71.36,134.06
GND on IN1: 151.76,110.24 154.69,110.24 158.5,106.43 158.5,59.94 157.35,58.8 153.92,58.8 149.86,62.87 145.54,62.87 145.16,63.25 145.16,65.91 145.92,66.67 148.97,66.67 150.11,67.82 150.11,77.34 153.54,80.77 153.54,87.76 153.29,88.01 153.29,101.98 149.86,105.41 149.86,108.33
GND on IN1: 53.52,115.01 63.65,115.01 64.01,114.66 64.01,108.43 63.7,108.13 54.53,108.13 53.29,109.37 53.29,114.78
GND on IN2: 1.85,198.65 22.02,198.65 22.07,198.6 22.07,189.05 26.14,184.99 26.14,183.85 25.98,183.69 24,183.69 22.43,182.12 9.37,182.12 4.6,177.34 1.85,177.34 1.3,177.9 1.3,198.09
GND on IN2: 108.79,118.29 110.21,119.71 110.21,164.64 112.57,167 113.87,167 114.48,167.61 114.48,174.88 113.92,175.44 89.33,175.44 87.25,173.35 87.25,165.07 92.41,159.92 92.41,159.89 92.61,159.69 92.61,158.62 92.41,158.42 92.41,138.84 86.11,132.54 69.04,132.54 68.35,133.22 68.35,163.19 66.4,165.15 57.38,165.15 57.38,163.3 57.1,163.02 53.92,163.02 53.92,164.19 52.96,165.15 36.8,165.15 36.02,164.36 36.02,159.87 33.1,156.95 33.1,138.96 35.33,136.73 35.33,119.05 36.09,118.29
GND on IN2: outline of 167 points within 94.39,153.57 158.65,198.55
GND on VCC: 0.51,199.49 22.1,199.49 22.1,189.61 22.19,189.12 22.47,188.71 26.28,184.9 26.69,184.63 27.18,184.53 28.96,184.53 28.96,178.05 25.4,178.05 25.3,178.03 25.22,177.98 24.71,177.47 24.66,177.39 24.64,177.29 24.64,174.22 24.41,173.99 20.83,173.99 20.73,173.97 20.65,173.92 18.74,172.01 18.69,171.93 18.67,171.83 18.67,169.4 15.9,166.62 13.21,166.62 13.11,166.6 13.03,166.55 10.49,164.01 10.43,163.93 10.41,163.83 10.41,159.74 3.83,153.16 0.51,153.16
GND on VCC: 132.57,60.2 135.28,60.2 136.02,59.46 136.02,57.13 135.91,57.02 132.19,57.02 132.08,57.13 132.08,59.71
GND on VCC: 93.45,68.58 95.91,68.58 96.27,68.22 96.27,65.26 95.78,64.77 93.45,64.77 93.22,65 93.22,68.35
GND on VCC: 8.87,33.78 13.74,33.78 17.02,30.5 17.02,25.63 12.85,21.46 9.63,21.46 5.46,25.63 5.46,30.37
GND on VCC: 42.65,72.52 44.98,72.52 45.09,72.41 45.09,69.19 44.73,68.83 42.9,68.83 42.04,69.7 42.04,71.9
GND on VCC: 30.79,28.83 33.63,28.83 34.11,28.34 34.11,25.25 33.63,24.77 30.92,24.77 30.3,25.38 30.3,28.34
GND on VCC: 65.84,25.91 68.68,25.91 69.16,25.42 69.16,22.33 68.68,21.84 65.97,21.84 65.35,22.46 65.35,25.42
GND on VCC: 103.12,199.49 159.49,199.49 159.49,144.02 158.86,144.02 158.93,144.09 158.98,144.17 159,144.27 159,156.08 158.98,156.18 158.93,156.26 157.91,157.28 157.83,157.33 157.73,157.35 147.45,157.35 147.35,157.33 147.27,157.28 146.18,156.19 146.18,159.89 146.16,159.99 146.1,160.07 144.02,162.16 144.02,165.74 144,165.83 143.94,165.91 140.72,169.14 140.72,177.8 140.7,177.9 140.64,177.98 136.96,181.66 136.88,181.72 136.78,181.74 92.84,181.74 92.91,181.79 92.97,181.85 102.75,191.63 103.03,192.05 103.12,192.53
GND on VCC: 102.42,25.78 105.25,25.78 105.74,25.29 105.74,22.2 105.25,21.72 102.54,21.72 101.93,22.33 101.93,25.29
GND on VCC: 138.99,26.16 141.83,26.16 142.32,25.68 142.32,22.58 141.83,22.1 139.12,22.1 138.51,22.71 138.51,25.68
GND on VCC: 89.66,98.3 92.86,98.3 92.91,98.25 92.99,98.19 93.09,98.17 94.74,98.17 94.74,94.09 94.38,93.73 90.02,93.73 89.66,94.09
GND on VCC: 69.45,112.14 72.41,112.14 72.77,111.78 72.77,109.2 72.54,108.97 69.07,108.97 68.83,109.2 68.83,111.53
GND on VCC: 120.7,25.91 123.54,25.91 124.03,25.42 124.03,22.33 123.54,21.84 120.83,21.84 120.22,22.46 120.22,25.42
GND on VCC: 14.71,138.05 27.07,138.05 34.67,130.45 34.67,109.6 27.05,109.6 26.95,109.58 26.87,109.53 25.98,108.64 25.93,108.56 25.91,108.46 25.91,99.67 25.09,98.86 25.04,98.78 25.02,98.68 25.02,88.5 24.82,88.7 24.74,88.75 24.64,88.77 21.7,88.77 21.26,89.21 21.18,89.26 21.08,89.28 12.7,89.28 12.6,89.26 12.52,89.21 11.76,88.44 11.7,88.36 11.68,88.27 11.68,86.34 10.94,85.6 0.51,85.6 0.51,118.75 9.78,118.75 9.88,118.76 9.96,118.82 10.34,119.2 10.39,119.28 10.41,119.38 10.41,129.05 12.12,130.76 12.17,130.84 12.19,130.94 12.19,135.53
GND on VCC: 71.48,158.88 75.08,158.88 75.56,158.39 75.56,154.41 74.82,153.67 71.99,153.67 70.87,154.79 70.87,158.26
GND on VCC: 81.21,130.94 83.22,130.94 83.29,130.86 83.39,130.82 83.44,130.66 83.57,129.15 83.57,128.78 83.57,128.74 83.7,128.36 84.08,126.97 84.46,124.06 84.46,124.04 84.47,124.01 85.24,122.74 85.25,122.73 87.01,120.58 87.25,120.11 87.38,117.98 87.38,117.95 87.39,117.93 88.02,116.66 88.05,116.62 88.56,116.12 88.58,116.1 88.6,116.09 88.69,115.99 88.82,115.95 88.97,115.95 89.03,115.9 89.03,113.08 88.72,112.78 85.65,112.78 85.34,113.08 85.34,114.94 85.33,114.98 85.31,115.02 84.58,115.75 84.58,118.87 84.57,118.92 84.54,118.96 84.07,119.43 84.07,120.4 84.07,120.44 83.94,120.82 83.93,120.85 83.42,121.61 83.4,121.63 83.38,121.65 82.38,122.27 80.88,124.27 80.51,125.15 80.49,125.17 78.99,127.17 78.99,129.49 79.3,129.79 80.01,129.79 80.06,129.8 80.1,129.83
GND on VCC: 47.55,25.78 50.39,25.78 50.88,25.29 50.88,22.2 50.39,21.72 47.68,21.72 47.07,22.33 47.07,25.29
GND on VCC: 84.13,25.91 86.97,25.91 87.45,25.42 87.45,22.33 86.97,21.84 84.26,21.84 83.64,22.46 83.64,25.42
GND on VCC: 143.51,41.53 143.61,41.55 143.69,41.6 143.97,41.88 144.67,41.17 144.84,41.06 145.03,41.02 149.99,41.02 150.18,41.06 150.35,41.17 150.71,41.53 152.57,41.53 153.16,40.94 153.16,23.37 146.16,23.37 145.34,24.18 145.26,24.24 145.16,24.26 142.82,24.26 142.82,25.78 142.8,25.88 142.75,25.96 142.75,41.53
GND on IN3: 39.62,31.8 43.03,31.8 43.13,31.7 43.13,28.22 43.08,28.17 39.6,28.17 39.52,28.24 39.52,31.7
GND on IN3: 76.2,31.8 79.6,31.8 79.71,31.7 79.71,28.22 79.65,28.17 76.17,28.17 76.1,28.24 76.1,31.7
GND on IN3: 9.86,14 145.72,14 147.57,15.85 147.57,17.25 148.74,18.41 151.74,18.41 152.17,18.85 152.17,20.73 153.14,21.69 153.14,39.85 152.4,40.59 144.4,40.59 143.41,39.6 143.41,21.77 142.9,21.26 138.25,21.26 136.73,22.78 131.62,22.78 130.18,21.34 120.04,21.34 119.13,22.25 107.16,22.25 106.05,21.13 101.83,21.13 100.76,22.2 94.64,22.2 93.7,21.26 83.03,21.26 81.99,22.3 70.31,22.3 69.32,21.31 65.15,21.31 63.88,22.58 59.56,22.58 58.8,23.34 53.16,23.34 51.18,21.36 46.91,21.36 46,22.28 39.85,22.28 39.47,21.89 29.95,21.89 28.02,23.83 19.23,23.83 15.65,27.41 15.65,34.47 14.88,35.23 2.62,35.23 1.96,34.57 1.96,21.89
GND on IN3: 57.91,31.8 61.32,31.8 61.42,31.7 61.42,28.22 61.37,28.17 57.89,28.17 57.81,28.24 57.81,31.7
GND on IN3: 141.6,181.74 143.97,184.1 143.97,190.96 144.32,191.31 149.83,191.31 150.5,191.97 158.06,191.97 158.39,192.3 158.39,198.4 158.14,198.65 103.99,198.65 103.17,197.84 103.17,192.02 97.23,186.08 97.23,182.5 97.99,181.74
GND on IN3: 90.58,97.79 94.13,97.79 94.59,97.33 94.59,95.07 93.12,93.6 89.94,93.6 89.69,93.85 89.69,96.9
GND on IN3: 132.11,60.2 135.92,60.2 136.04,60.07 136.04,57.15 135.92,57.02 132.11,57.02 131.98,57.15 131.98,60.07
GND on IN3: 129.57,50.55 132.61,50.55 132.74,50.42 132.74,47.24 132.61,47.12 129.57,47.12 129.44,47.24 129.44,50.42
GND on IN3: 112.78,31.8 116.18,31.8 116.28,31.7 116.28,28.22 116.23,28.17 112.75,28.17 112.67,28.24 112.67,31.7
GND on IN3: 94.49,31.8 97.89,31.8 97.99,31.7 97.99,28.22 97.94,28.17 94.46,28.17 94.39,28.24 94.39,31.7
GND on IN3: outline of 167 points within 20.45,83.91 66.09,173.71
GND on IN3: 10.74,78.36 18.06,78.36 18.29,78.13 18.29,73.38 17.55,72.64 17.55,69.57 17.27,69.29 10.72,69.29 10.41,69.6 10.41,78.03
GND on IN3: outline of 238 points within 24.66,36.4 111.3,73.63
GND on IN3: 131.06,32.18 134.47,32.18 134.57,32.08 134.57,28.6 134.52,28.55 131.04,28.55 130.96,28.63 130.96,32.08
GND on GND2: 103.12,199.49 159.49,199.49 159.49,58.67 153.88,58.67 149.97,62.59 149.8,62.7 149.61,62.74 145.03,62.74 144.84,62.7 144.67,62.59 143.91,61.83 143.8,61.66 143.76,61.47 143.76,42.29 143.8,42.1 143.91,41.93 144.67,41.17 144.84,41.06 145.03,41.02 149.99,41.02 150.18,41.06 150.35,41.17 150.71,41.53 152.57,41.53 153.16,40.94 153.16,18.5 153.08,18.41 148.97,18.41 148.78,18.38 148.61,18.27 147.72,17.38 147.61,17.21 147.57,17.02 147.57,15.83 145.71,13.97 9.86,13.97 7.09,16.74 6.93,16.85 6.73,16.89 0.51,16.89 0.51,199.49 22.1,199.49 22.1,189.61 22.19,189.12 22.47,188.71 26.28,184.9 26.69,184.63 27.18,184.53 33.64,184.53 36.19,181.98 36.6,181.71 37.08,181.61 41.13,181.61 41.77,180.97 42.19,180.69 42.67,180.59 62.48,180.59 62.97,180.69 63.38,180.97 63.9,181.48 92.08,181.48 92.56,181.58 92.97,181.85 102.75,191.63 103.03,192.05 103.12,192.53 ; 1 cut-out
GNDA on TOP (solid shape): 73.23,107.9 73.23,105.74 73.1,105.61 71.83,105.61 71.7,105.74 71.7,106.73 71.78,106.81 72.09,106.81 72.25,106.97 72.25,107.84 72.39,107.98 73.15,107.98
GNDA on TOP: 65.84,88.44 66.24,88.04 67.31,88.04 67.84,88.57 69.55,88.57 70.13,89.15 70.13,94.49 70.46,94.82 73.05,94.82 74.23,93.64 74.23,88.81 74.02,88.6 73.43,88.6 73.18,88.34 73.18,87.4 73.03,87.25 72.64,87.25 72.14,87.76 71.7,87.76 71.58,87.63 71.58,85.34 71.22,84.99 68.28,84.99 67.69,85.57 67.69,86.77 67.39,87.07 66.12,87.07 65.49,86.45 65.49,85.38 65.06,84.95 64.48,84.95 64.47,84.94 57.28,84.94 57.12,85.09 57.12,86.59 56.77,86.94 55.73,86.94 55.55,86.77 55.55,85.24 55.24,84.94 52.7,84.94 52.5,85.14 52.5,88.75 53.05,89.29 56.64,89.29 57.49,88.44
GNDA on TOP: 52.53,106.88 54.43,106.88 54.56,106.76 54.56,105.61 52.91,103.96 52.53,103.96 52.4,104.09 52.4,106.76
GNDA on IN1: 74.75,106.88 74.75,86.11 74.24,85.6 69.27,85.6 69.13,85.74 69.13,87.72 68.91,87.93 67.82,87.93 67.64,88.11 67.64,88.42 67.34,88.72 66.12,88.72 65.89,88.49 65.89,87.3 63.75,85.17 58.88,85.17 58.78,85.27 58.78,87.55 58.45,87.88 54.64,87.88 53.92,87.17 53.92,85.78 53.57,85.42 52.27,85.42 51.89,85.8 51.89,92.48 52.58,93.17 52.58,106.32 53.31,107.06 62.76,107.06 62.79,107.09 74.55,107.09
GNDA on IN3: 52.65,88.65 61.62,88.65 61.8,88.47 61.8,86.56 60.83,85.6 52.15,85.6 51.89,85.85 51.89,87.88
V0P9_LAN1 on TOP: 28.07,38.33 30.84,38.33 31.06,38.1 31.06,35.94 30.86,35.74 29.97,35.74 29.82,35.89 29.82,37.08 29.64,37.26 27.94,37.26 27.86,37.34 27.86,38.13
V0P9_LAN1 on TOP: 23.62,27.05 23.5,26.92 21.84,26.92 21.72,27.05 21.72,28.65 21.79,28.73 23.55,28.73 23.62,28.65
V0P9_LAN1 on IN3: 29.72,38.18 29.72,33.78 30.35,33.15 30.35,31.88 29.34,30.86 29.34,30.1 28.35,29.11 28.35,28.22 28.07,27.94 24.51,27.94 23.75,27.18 22.12,27.18 19.68,29.62 19.68,33.78 19.43,34.04 19.05,34.04 18.92,34.16 18.92,36.07 21.21,38.35 29.54,38.35
V0P9_LAN2 on TOP: 40.39,24.13 40.26,24 38.61,24 38.48,24.13 38.48,25.73 38.56,25.81 40.31,25.81 40.39,25.73
V0P9_LAN2 on TOP: 45.09,35.43 47.75,35.43 47.88,35.31 47.88,32.89 47.75,32.77 46.61,32.77 46.35,33.02 46.35,34.16 46.18,34.34 44.65,34.34 44.58,34.42 44.58,34.92
V0P9_LAN2 on IN3: 46.48,35.26 46.48,30.86 47.12,30.23 47.12,28.96 46.1,27.94 46.1,27.18 45.11,26.19 45.11,25.3 44.83,25.02 41.27,25.02 40.51,24.26 38.23,24.26 38.1,24.38 38.1,26.8 36.45,28.45 36.45,30.86 36.2,31.11 35.81,31.11 35.69,31.24 35.69,33.15 37.97,35.43 46.3,35.43
V0P9_LAN3 on TOP: 63.37,35.43 66.04,35.43 66.17,35.31 66.17,32.89 66.04,32.77 64.9,32.77 64.64,33.02 64.64,34.16 64.47,34.34 62.94,34.34 62.87,34.42 62.87,34.92
V0P9_LAN3 on TOP: 58.67,24.13 58.55,24 56.9,24 56.77,24.13 56.77,25.73 56.85,25.81 58.6,25.81 58.67,25.73
V0P9_LAN3 on IN3: 64.64,35.81 64.77,35.69 64.77,30.86 65.41,30.23 65.41,28.96 64.39,27.94 64.39,27.05 63.5,26.16 63.5,25.15 63.37,25.02 59.56,25.02 58.8,24.26 56.52,24.26 56.39,24.38 56.39,26.8 54.74,28.45 54.74,30.86 54.48,31.11 54.1,31.11 53.98,31.24 53.98,33.15 56.64,35.81
V0P9_LAN4 on TOP: 81.66,35.43 84.33,35.43 84.45,35.31 84.45,32.89 84.33,32.77 83.19,32.77 82.93,33.02 82.93,34.16 82.75,34.34 81.23,34.34 81.15,34.42 81.15,34.92
V0P9_LAN4 on TOP: 76.96,24.13 76.83,24 75.18,24 75.06,24.13 75.06,25.73 75.13,25.81 76.89,25.81 76.96,25.73
V0P9_LAN4 on IN3: 83.19,35.43 83.19,31.75 83.06,31.62 83.06,30.86 83.69,30.23 83.69,28.96 82.68,27.94 82.68,25.27 82.42,25.02 77.85,25.02 77.09,24.26 74.8,24.26 74.68,24.38 74.68,26.8 73.03,28.45 73.03,30.86 72.77,31.11 72.39,31.11 72.26,31.24 72.26,33.15 74.68,35.56 83.06,35.56
V0P9_LAN5 on TOP: 95.25,24.13 95.12,24 93.47,24 93.34,24.13 93.34,25.73 93.42,25.81 95.17,25.81 95.25,25.73
V0P9_LAN5 on TOP: 99.95,35.43 102.62,35.43 102.74,35.31 102.74,32.89 102.62,32.77 101.47,32.77 101.22,33.02 101.22,34.16 101.09,34.29 99.57,34.29 99.44,34.42 99.44,34.92
V0P9_LAN5 on IN3: 101.35,35.26 101.35,30.86 101.98,30.23 101.98,28.96 100.97,27.94 100.97,25.27 100.71,25.02 96.14,25.02 95.38,24.26 93.09,24.26 92.96,24.38 92.96,26.8 91.31,28.45 91.31,30.86 91.06,31.11 90.68,31.11 90.55,31.24 90.55,33.15 92.84,35.43 101.17,35.43
V0P9_LAN6 on TOP: 118.24,35.43 120.9,35.43 121.03,35.31 121.03,32.89 120.9,32.77 119.76,32.77 119.51,33.02 119.51,34.16 119.38,34.29 117.86,34.29 117.73,34.42 117.73,34.92
V0P9_LAN6 on TOP: 113.54,24.13 113.41,24 111.76,24 111.63,24.13 111.63,25.73 111.71,25.81 113.46,25.81 113.54,25.73
V0P9_LAN6 on IN3: 119.63,35.33 119.63,30.86 120.27,30.23 120.27,28.96 119.48,28.17 119.48,27.46 118.16,26.14 118.16,25.22 117.96,25.02 114.43,25.02 113.67,24.26 111.38,24.26 111.25,24.38 111.25,26.8 109.6,28.45 109.6,30.86 109.35,31.11 108.97,31.11 108.84,31.24 108.84,32.89 111,35.05 117.09,35.05 117.58,35.53 119.43,35.53
V0P9_LAN7 on TOP: 131.83,24.51 131.7,24.38 130.05,24.38 129.92,24.51 129.92,26.11 130,26.19 131.75,26.19 131.83,26.11
V0P9_LAN7 on TOP: 136.53,35.81 139.19,35.81 139.32,35.69 139.32,33.27 139.19,33.15 138.05,33.15 137.79,33.4 137.79,34.54 137.62,34.72 136.09,34.72 136.02,34.8 136.02,35.31
V0P9_LAN7 on IN3: 137.79,35.81 137.92,35.69 137.92,30.86 138.56,30.23 138.56,28.96 137.54,27.94 137.54,27.15 135.97,25.58 132.44,25.58 132.21,25.35 132.21,24.51 131.95,24.26 129.67,24.26 129.54,24.38 129.54,26.8 127.89,28.45 127.89,30.86 127.64,31.11 127.25,31.11 127.13,31.24 127.13,33.15 129.79,35.81
V0P9_LAN8 on TOP: 125.6,52.58 125.6,55.24 125.73,55.37 128.14,55.37 128.27,55.24 128.27,54.1 128.02,53.85 126.87,53.85 126.75,53.72 126.75,52.2 126.62,52.07 126.11,52.07
V0P9_LAN8 on TOP: 136.91,47.88 137.03,47.75 137.03,46.1 136.91,45.97 135.31,45.97 135.23,46.05 135.23,47.8 135.31,47.88
V0P9_LAN8 on IN3: 126.26,54.99 133.63,54.99 133.88,54.74 133.88,53.34 134.65,52.58 134.65,49.91 136.68,47.88 136.68,43.81 135.92,43.05 126.52,43.05 125.88,43.69 125.88,49.28 125.37,49.78 125.37,54.1
V1P5_LAN1 on TOP: 31.22,32.13 31.22,30.02 31.17,29.97 30.45,29.97 30.3,29.82 30.3,29.46 30.2,29.36 29.13,29.36 29.06,29.44 29.06,31.47 29.21,31.62 29.95,31.62 30.33,32 30.33,32.13 30.45,32.26 31.09,32.26
V1P5_LAN1 on TOP: 24.08,27.28 24,27.36 24,28.68 24.05,28.73 25.22,28.73 25.27,28.68 25.27,27.33 25.22,27.28
V1P5_LAN2 on TOP: 40.84,24.36 40.77,24.43 40.77,25.76 40.82,25.81 41.99,25.81 42.04,25.76 42.04,24.41 41.99,24.36
V1P5_LAN2 on TOP: 47.98,29.21 47.98,27.1 47.93,27.05 47.22,27.05 47.07,26.9 47.07,26.54 46.96,26.44 45.9,26.44 45.82,26.52 45.82,28.55 45.97,28.7 46.71,28.7 47.09,29.08 47.09,29.21 47.22,29.34 47.85,29.34
V1P5_LAN3 on TOP: 66.27,29.21 66.27,27.1 66.22,27.05 65.51,27.05 65.35,26.9 65.35,26.54 65.25,26.44 64.19,26.44 64.11,26.52 64.11,28.55 64.26,28.7 65,28.7 65.38,29.08 65.38,29.21 65.51,29.34 66.14,29.34
V1P5_LAN3 on TOP: 59.13,24.36 59.05,24.43 59.05,25.76 59.11,25.81 60.27,25.81 60.33,25.76 60.33,24.41 60.27,24.36
V1P5_LAN4 on TOP: 77.42,24.36 77.34,24.43 77.34,25.76 77.39,25.81 78.56,25.81 78.61,25.76 78.61,24.41 78.56,24.36
V1P5_LAN4 on TOP: 84.56,29.21 84.56,27.1 84.51,27.05 83.79,27.05 83.64,26.9 83.64,26.54 83.54,26.44 82.47,26.44 82.4,26.52 82.4,28.55 82.55,28.7 83.29,28.7 83.67,29.08 83.67,29.21 83.79,29.34 84.43,29.34
V1P5_LAN5 on TOP: 102.84,29.21 102.84,27.1 102.79,27.05 102.08,27.05 101.93,26.9 101.93,26.54 101.83,26.44 100.76,26.44 100.69,26.52 100.69,28.55 100.84,28.7 101.57,28.7 101.96,29.08 101.96,29.21 102.08,29.34 102.72,29.34
V1P5_LAN5 on TOP: 95.71,24.36 95.63,24.43 95.63,25.76 95.68,25.81 96.85,25.81 96.9,25.76 96.9,24.41 96.85,24.36
V1P5_LAN6 on TOP: 114,24.36 113.92,24.43 113.92,25.76 113.97,25.81 115.14,25.81 115.19,25.76 115.19,24.41 115.14,24.36
V1P5_LAN6 on TOP: 121.13,29.21 121.13,27.1 121.08,27.05 120.37,27.05 120.22,26.9 120.22,26.54 120.12,26.44 119.05,26.44 118.97,26.52 118.97,28.55 119.13,28.7 119.86,28.7 120.24,29.08 120.24,29.21 120.37,29.34 121.01,29.34
V1P5_LAN7 on TOP: 139.42,29.59 139.42,27.48 139.37,27.43 138.66,27.43 138.51,27.28 138.51,26.92 138.4,26.82 137.34,26.82 137.26,26.9 137.26,28.93 137.41,29.08 138.15,29.08 138.53,29.46 138.53,29.59 138.66,29.72 139.29,29.72
V1P5_LAN7 on TOP: 132.28,24.74 132.21,24.82 132.21,26.14 132.26,26.19 133.43,26.19 133.48,26.14 133.48,24.79 133.43,24.74
V1P5_LAN8 on TOP: 136.68,48.34 136.6,48.26 135.28,48.26 135.23,48.31 135.23,49.48 135.28,49.53 136.63,49.53 136.68,49.48
V1P5_LAN8 on TOP: 131.83,55.47 133.86,55.47 133.88,55.5 134.49,55.5 134.59,55.4 134.59,53.52 134.52,53.44 132.49,53.44 132.33,53.59 132.33,54.2 131.95,54.58 131.83,54.58 131.7,54.71 131.7,55.35
V3.3_M2_B on TOP: 150.37,194.18 151.26,193.29 151.26,191.01 151.51,190.75 153.29,190.75 153.54,190.5 153.54,186.56 153.29,186.31 150.37,186.31 150.11,186.06 150.11,181.1 150.24,180.97 151.13,180.97 151.26,180.85 151.26,175.77 150.75,175.26 140.34,175.26 140.21,175.39 140.21,180.21 140.46,180.47 142.37,180.47 145.03,183.13 147.32,183.13 148.08,183.9 148.08,187.96 147.7,188.34 144.53,188.34 144.27,188.59 144.27,193.8 144.65,194.18
V3.3_M2_B on BOTTOM: 141.81,177.42 143.13,177.42 143.26,177.29 143.26,176.15 143.13,176.02 141.99,176.02 141.86,176.15 141.86,176.78 141.73,176.91 140.89,176.91 140.82,176.99 140.82,177.29 140.87,177.34 141.73,177.34
V3.3_M2_B on IN1: 144.53,175.13 153.03,175.13 153.42,175.51 153.42,194.82 153.16,195.07 144.53,195.07 144.02,194.56 144.02,185.01 141.91,182.91 141.91,175.31 142.07,175.15 144.51,175.15
V3P3_LAN1 on TOP: 34.09,40.01 34.32,39.78 34.32,38.46 32.77,36.91 32.77,33.27 33.23,32.81 33.23,32.34 32.77,31.88 32.59,31.97 32.38,32 31.99,31.87 31.75,31.53 31.74,31.5 31.62,31.5 31.5,31.62 31.5,32.21 31.54,32.29 31.63,32.31 31.69,32.29 31.75,32.29 32.11,32.64 31.75,33 31.69,32.99 31.63,32.98 31.54,32.99 31.5,33.07 31.5,38.43 31.24,38.68 26.11,38.68 25.91,38.48 25.91,37.36 25.81,37.26 20.5,37.26 19.84,36.6 19.84,35.53 18.8,34.49 18.8,34.11 19.05,33.86 19.84,33.86 19.94,33.76 19.94,32.79 19.81,32.66 19.02,32.66 18.8,32.44 18.8,29.18 19.61,28.37 21.21,28.37 21.39,28.19 21.39,26.75 21.56,26.57 25.45,26.57 25.65,26.77 25.65,28.68 25.7,28.73 28.19,28.73 28.32,28.6 28.32,23.77 27.94,23.39 18.03,23.39 17.65,23.77 17.65,31.24 13.59,35.31 13.59,41.15 14.22,41.78 33.91,41.78 34.09,41.61 ; 1 cut-out
V3P3_LAN2 on TOP: 35.43,36.09 35.43,37.39 35.28,37.54 35.1,37.54 35.09,37.55 34.96,37.55 34.87,37.64 34.87,39.62 35,39.75 50.88,39.75 51.16,39.47 51.16,31.8 52.02,30.94 52.02,20.7 51.79,20.47 34.8,20.47 34.42,20.85 34.42,30.48 34.75,30.81 34.75,32.49 34.7,32.54 34.7,34.01 35.18,34.49 35.18,35.84 ; 1 cut-out
V3P3_LAN2 on BOTTOM: 44.96,39.5 49.4,39.5 49.53,39.37 49.53,37.97 49.4,37.85 44.96,37.85 44.83,37.97 44.83,39.37
V3P3_LAN3 on TOP: 53.72,36.09 53.72,37.39 53.57,37.54 52.58,37.54 52.43,37.69 52.43,39.62 52.68,39.88 67.92,39.88 68.43,39.37 68.43,30.02 69.9,28.55 69.9,26.37 70.31,25.96 70.31,20.7 70.08,20.47 53.09,20.47 52.7,20.85 52.7,30.48 53.04,30.81 53.04,32.49 52.98,32.54 52.98,34.01 53.47,34.49 53.47,35.84 ; 1 cut-out
V3P3_LAN3 on BOTTOM: 63.27,39.88 67.16,39.88 67.26,39.78 67.26,37.95 67.18,37.87 63.22,37.87 63.14,37.95 63.14,39.75
V3P3_LAN4 on TOP: 72.01,36.09 72.01,37.39 71.86,37.54 70.87,37.54 70.71,37.69 70.71,39.62 70.97,39.88 85.7,39.88 86.72,38.86 86.72,30.02 88.6,28.14 88.6,20.7 88.37,20.47 71.37,20.47 70.99,20.85 70.99,26.29 70.61,26.67 70.61,30.68 71.32,31.39 71.32,32.49 71.27,32.54 71.27,34.01 71.75,34.49 71.75,35.84 ; 1 cut-out
V3P3_LAN4 on BOTTOM: 81.61,39.37 85.88,39.37 86,39.24 86,37.9 85.88,37.77 81.58,37.77 81.48,37.87 81.48,39.24
V3P3_LAN5 on TOP: 90.3,36.09 90.3,37.39 90.14,37.54 89.15,37.54 89,37.69 89,38.48 89.64,39.12 104.22,39.12 105,38.33 105,30.02 106.88,28.14 106.88,20.7 106.65,20.47 89.66,20.47 89.28,20.85 89.28,30.48 89.61,30.81 89.61,32.49 89.56,32.54 89.56,34.01 90.04,34.49 90.04,35.84 ; 1 cut-out
V3P3_LAN5 on BOTTOM: 99.92,39.17 104.65,39.17 104.75,39.07 104.75,37.74 104.62,37.62 99.87,37.62 99.75,37.74 99.75,38.99
V3P3_LAN6 on TOP: 108.58,36.09 108.58,37.64 108.33,37.9 107.43,37.9 107.35,37.97 107.35,39.05 107.63,39.33 111.19,39.33 112.8,37.72 114.71,37.72 115.93,38.94 115.93,39.75 116.15,39.98 121.59,39.98 123.29,38.28 123.29,30.02 125.17,28.14 125.17,20.7 124.94,20.47 107.95,20.47 107.57,20.85 107.57,30.48 107.9,30.81 107.9,32.49 107.85,32.54 107.85,34.01 108.33,34.49 108.33,35.84 ; 1 cut-out
V3P3_LAN6 on BOTTOM: 118.16,39.95 121.97,39.95 122.1,39.83 122.1,38 121.97,37.87 118.11,37.87 118.01,37.97 118.01,39.8
V3P3_LAN7 on TOP: 126.87,36.47 126.87,37.9 126.62,38.15 125.83,38.15 125.69,38.29 125.69,40.11 125.76,40.17 125.76,40.18 125.91,40.34 130.02,40.34 130.56,40.87 133.65,40.87 133.83,40.69 133.83,40.34 134.11,40.06 137.62,40.06 137.72,40.16 141.1,40.16 141.58,39.67 141.58,30.4 143.46,28.52 143.46,21.08 143.23,20.85 126.24,20.85 125.86,21.23 125.86,30.86 126.19,31.19 126.19,32.87 126.14,32.92 126.14,34.39 126.62,34.87 126.62,36.22 ; 1 cut-out
V3P3_LAN8 on TOP: 124.94,42.93 123.65,42.93 123.49,42.77 123.49,42.06 123.42,41.99 122.07,41.99 121.95,42.11 121.95,50.55 123.47,52.07 123.47,60.71 124.23,61.47 138.94,61.47 139.75,60.66 139.75,46.28 138.86,45.39 138.86,45.01 135.76,41.91 130.56,41.91 130.18,42.29 128.37,42.29 128.3,42.21 127,42.21 126.54,42.67 125.2,42.67 ; 1 cut-out
V3P3_LAN8 on BOTTOM: 125.25,61.47 128.93,61.47 129.06,61.34 129.06,59.56 128.93,59.44 126.39,59.44 126.14,59.18 125.12,59.18 124.99,59.31 124.99,61.21
VCC5_USB1 on TOP: 96.6,63.2 103.58,63.2 104.22,63.83 110.19,63.83 110.57,63.45 110.57,61.93 110.19,61.54 107.26,61.54 106.25,60.53 95.58,60.53 95.45,60.66 95.45,62.05
VCC5_USB2 on TOP (solid shape): 79.1,54.56 79.12,54.56 79.14,54.54 79.23,54.45 79.24,54.43 79.25,54.41 79.25,53.77 79.25,53.75 79.26,53.73 80.45,52.54 80.46,52.53 80.47,52.51 80.47,49.75 80.46,49.73 80.45,49.72 80.2,49.48 76.33,49.48 75.96,49.85 75.96,52.18 75.97,52.2 75.97,52.22 75.97,54.16 75.98,54.18 75.99,54.19 76.34,54.54 76.35,54.56 76.37,54.56
VCC5_USB2 on BOTTOM: 88.09,51.46 88.09,43.51 87.83,43.26 84.28,43.26 84.02,43.51 84.02,45.03 83.39,45.67 81.36,45.67 80.98,46.05 80.98,47.57 80.35,48.2 79.24,48.2 78.51,48.92 78.51,51.54 78.66,51.69 82.42,51.69 82.44,51.7 87.85,51.7
