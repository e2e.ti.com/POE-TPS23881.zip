# Allegro board POE TPS23881.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RB4  10K-R2  [SM0402_R]  131.19 174.24 180 top
RB5  10K-R2  [SM0402_R]  132.84 164.21 0 top
RB6  10K-R2  [SM0402_R]  129.92 161.04 270 top
RB7  10K-R2  [SM0402_R]  131.06 161.04 270 top
RB8  10K-R2  [SM0402_R]  123.32 159.13 180 top
RB9  10K-R2  [SM0402_R]  127.38 159.13 0 top
RB10  10K-R2  [SM0402_R]  134.87 158.12 90 top
RB11  10K-R2  [SM0402_R]  127.38 157.86 0 top
RB12  10K-R2  [SM0402_R]  107.21 155.7 270 top
RB13  10K-R2  [SM0402_R]  133.73 155.07 90 top
RB14  0-R1  [SM0201_R]  32.13 30.48 0 bottom
RB15  0-R1  [SM0201_R]  48.9 27.56 0 bottom
RB16  0-R1  [SM0201_R]  67.18 27.56 0 bottom
RB17  0-R1  [SM0201_R]  85.47 27.56 0 bottom
RB18  0-R1  [SM0201_R]  103.76 27.56 0 bottom
RB19  0-R1  [SM0201_R]  122.05 27.56 0 bottom
RB20  0-R1  [SM0201_R]  140.34 27.94 0 bottom
RB21  0-R1  [SM0201_R]  133.73 55.24 90 bottom
RB22  10K-R2  [SM0402_R]  114.3 154.18 270 top
RB23  10K-R2  [SM0402_R]  51.94 150.75 0 top
RB24  10K-R2  [SM0402_R]  115.82 123.06 90 top
RB25  10K-R2  [SM0402_R]  115.82 120.27 90 top
RB26  10K-R2  [SM0402_R]  39.88 111.63 270 top
RB27  10K-R2  [SM0402_R]  41.27 109.22 90 top
RB28  10K-R2  [SM0402_R]  42.88 109.17 90 top
RB29  10K-R2  [SM0402_R]  12.32 107.06 270 top
RB30  10K-R2  [SM0402_R]  16.92 107.06 270 top
RB31  10K-R2  [SM0402_R]  39.45 103.58 0 top
RB32  10K-R2  [SM0402_R]  83.97 100.2 0 top
RB33  10K-R2  [SM0402_R]  39.45 102.44 0 top
RB34  10K-R2  [SM0402_R]  85.5 93.12 0 top
RB35  10K-R2  [SM0402_R]  85.5 91.97 0 top
RB36  10K-R2  [SM0402_R]  111.15 94.23 90 bottom
RB37  10K-R2  [SM0402_R]  109.63 96.52 0 bottom
RB38  10K-R2  [SM0402_R]  111.02 98.42 180 top
RB39  10K-R2  [SM0402_R]  111.91 94.23 180 top
RB40  10K-R2  [SM0402_R]  39.45 93.93 0 top
RB41  10K-R2  [SM0402_R]  39.45 92.79 0 top
RB42  10K-R2  [SM0402_R]  111.38 90.55 270 top
RB43  10K-R2  [SM0402_R]  116.36 88.14 180 top
RB44  10K-R2  [SM0402_R]  13.72 81.15 90 top
RB45  10K-R2  [SM0402_R]  15.82 81.1 90 top
RB46  10K-R2  [SM0402_R]  17.09 81.1 90 top
RB47  10K-R2  [SM0402_R]  121.67 77.34 90 top
RB48  10K-R2  [SM0402_R]  123.95 77.34 90 top
RB49  10K-R2  [SM0402_R]  125.09 77.34 90 top
RB50  10K-R2  [SM0402_R]  122.12 74.8 270 top
RB51  10K-R2  [SM0402_R]  121.06 71.96 90 top
RB52  10K-R2  [SM0402_R]  122.68 71.37 270 top
RB53  10K-R2  [SM0402_R]  123.85 71.37 270 top
RB54  10K-R2  [SM0402_R]  124.97 71.37 270 top
RB55  10K-R2  [SM0402_R]  121.06 69.34 90 top
RB56  10K-R2  [SM0402_R]  128.47 67.01 180 top
RB57  10K-R2  [SM0402_R]  128.47 65.86 180 top
RB58  10K-R2  [SM0402_R]  74.63 51.77 270 bottom
RB59  10K-R2  [SM0402_R]  74.12 56.46 180 top
RB60  10K-R2  [SM0402_R]  86.36 191.26 0 bottom
RB61  10K-R2  [SM0402_R]  86.36 177.29 0 bottom
RB62  10K-R2  [SM0402_R]  68.07 176.53 270 bottom
RB63  10K-R2  [SM0402_R]  132.46 155.45 180 bottom
RB64  10K-R2  [SM0402_R]  151.64 136.65 270 bottom
RB65  10K-R2  [SM0402_R]  13.16 81.61 0 bottom
RB66  10K-R2  [SM0402_R]  151.13 20.88 90 bottom
RECOVERY1  WF200-04/CI0104P1VK0  [WF200D-4P]  157.11 122.86 270 bottom
RESET1  WF200-04/CI0104P1VK0  [WF200D-4P]  157.14 134.17 270 bottom
RZ1  0-R2  [SM0402_R]  12.45 195.58 0 top
RZ2  0-R2  [SM0402_R]  136.4 175.51 90 top
RZ3  0-R2  [SM0402_R]  59.18 171.32 180 top
RZ4  0-R2  [SM0402_R]  112.14 159.89 0 top
RZ5  0-R2  [SM0402_R]  127.38 156.72 180 top
RZ6  0-R2  [SM0402_R]  127.38 154.18 180 top
RZ7  0-R2  [SM0402_R]  145.29 152.15 90 top
RZ8  0-R2  [SM0402_R]  68.83 150.75 180 top
RZ9  0-R2  [SM0402_R]  81.66 149.1 270 top
RZ10  0-R2  [SM0402_R]  82.8 149.1 270 top
RZ11  0-R2  [SM0402_R]  48.9 140.72 180 top
RZ12  0-R2  [SM0402_R]  136.22 140.08 180 top
RZ13  0-R2  [SM0402_R]  111.25 139.19 90 top
RZ14  0-R2  [SM0402_R]  98.3 138.94 270 top
RZ15  0-R2  [SM0402_R]  99.44 138.94 270 top
RZ16  0-R2  [SM0402_R]  100.58 138.94 270 top
RZ17  0-R2  [SM0402_R]  101.73 138.94 270 top
RZ18  0-R2  [SM0402_R]  102.87 138.94 270 top
RZ19  0-R2  [SM0402_R]  48.9 138.43 0 top
RZ20  0-R2  [SM0402_R]  121.79 133.99 270 top
RZ21  0-R2  [SM0402_R]  148.08 126.75 270 top
RZ22  0-R2  [SM0402_R]  149.22 126.75 270 top
RZ23  0-R2  [SM0402_R]  152.78 121.28 270 top
RZ24  0-R2  [SM0402_R]  21.87 117.6 180 top
RZ25  0-R2  [SM0402_R]  116.46 117.14 0 top
RZ26  0-R2  [SM0402_R]  21.87 116.33 180 top
RZ27  0-R2  [SM0402_R]  7.44 110.95 0 top
RZ28  0-R2  [SM0402_R]  80.67 109.73 180 top
RZ29  0-R2  [SM0402_R]  101.73 108.58 270 top
RZ30  0-R2  [SM0402_R]  80.67 108.46 180 top
RZ31  0-R2  [SM0402_R]  13.46 107.06 90 top
RZ32  0-R2  [SM0402_R]  95.02 103.89 270 top
RZ33  0-R2  [SM0402_R]  75.95 106.17 0 top
RZ34  0-R2  [SM0402_R]  101.73 106.17 270 top
RZ35  0-R2  [SM0402_R]  138.18 102.23 0 bottom
RZ36  0-R2  [SM0402_R]  143.76 102.23 0 bottom
RZ37  0-R2  [SM0402_R]  75.95 105.03 0 top
RZ38  0-R2  [SM0402_R]  138.18 103.38 0 bottom
RZ39  0-R2  [SM0402_R]  143.76 103.38 0 bottom
RZ40  0-R2  [SM0402_R]  138.18 104.52 0 bottom
RZ41  0-R2  [SM0402_R]  143.76 104.52 0 bottom
RZ42  0-R2  [SM0402_R]  75.95 103.89 0 top
RZ43  0-R2  [SM0402_R]  101.73 103.76 270 top
RZ44  0-R2  [SM0402_R]  102.87 103.76 270 top
RZ45  0-R2  [SM0402_R]  120.04 103.76 90 top
RZ46  0-R2  [SM0402_R]  138.18 105.66 0 bottom
RZ47  0-R2  [SM0402_R]  143.76 105.66 0 bottom
RZ48  0-R2  [SM0402_R]  75.95 102.74 0 top
RZ49  0-R2  [SM0402_R]  124.71 101.35 180 top
RZ50  0-R2  [SM0402_R]  75.95 101.6 0 top
RZ51  0-R2  [SM0402_R]  86 101.98 180 top
RZ52  0-R2  [SM0402_R]  75.95 100.46 0 top
RZ53  0-R2  [SM0402_R]  143.28 99.19 0 top
RZ54  0-R2  [SM0402_R]  75.95 99.31 0 top
RZ55  0-R2  [SM0402_R]  75.95 98.17 0 top
RZ56  0-R2  [SM0402_R]  92.86 102.08 0 top
RZ57  0-R2  [SM0402_R]  99.64 98.09 180 top
RZ58  0-R2  [SM0402_R]  135.66 89.66 0 top
RZ59  0-R2  [SM0402_R]  74.85 86.54 90 top
RZ60  0-R2  [SM0402_R]  73.69 83.62 270 top
RZ61  0-R2  [SM0402_R]  108.33 81.15 90 top
RZ62  0-R2  [SM0402_R]  10.16 81.15 90 top
RZ63  0-R2  [SM0402_R]  11.25 81.15 90 top
RZ64  0-R2  [SM0402_R]  12.57 81.15 90 top
RZ65  0-R2  [SM0402_R]  66.55 79.96 0 bottom
RZ66  0-R2  [SM0402_R]  8.13 78.36 0 top
RZ67  0-R2  [SM0402_R]  126.24 77.34 270 top
RZ68  0-R2  [SM0402_R]  74.04 76.07 180 top
RZ69  0-R2  [SM0402_R]  8.13 77.22 0 top
RZ70  0-R2  [SM0402_R]  21.84 76.83 90 top
RZ71  0-R2  [SM0402_R]  20.83 76.83 90 top
RZ72  0-R2  [SM0402_R]  121.06 74.8 90 top
RZ73  0-R2  [SM0402_R]  116.2 72.59 90 top
RZ74  0-R2  [SM0402_R]  92.53 70.43 0 top
RZ75  0-R2  [SM0402_R]  21.34 72.26 90 top
RZ76  0-R2  [SM0402_R]  73.86 72.97 90 top
RZ77  0-R2  [SM0402_R]  20.19 72.26 90 top
RZ78  0-R2  [SM0402_R]  116.23 69.98 90 top
RZ79  0-R2  [SM0402_R]  73.79 69.6 270 top
RZ80  0-R2  [SM0402_R]  43.94 68.33 0 top
RZ81  0-R2  [SM0402_R]  63.63 68.2 0 top
RZ82  0-R2  [SM0402_R]  91.01 67.13 270 top
RZ83  0-R2  [SM0402_R]  43.94 67.18 0 top
RZ84  0-R2  [SM0402_R]  40.39 67.18 180 top
RZ85  0-R2  [SM0402_R]  61.29 67.01 0 top
RZ86  0-R2  [SM0402_R]  125.22 66.8 180 top
RZ87  0-R2  [SM0402_R]  40.39 66.04 180 top
RZ88  0-R2  [SM0402_R]  43.94 65.91 180 top
RZ89  0-R2  [SM0402_R]  64.03 65.28 90 top
RZ90  0-R2  [SM0402_R]  73.74 65.61 180 top
RZ91  0-R2  [SM0402_R]  125.22 65.66 180 top
RZ92  0-R2  [SM0402_R]  40.39 64.64 180 top
RZ93  0-R2  [SM0402_R]  43.94 64.77 180 top
RZ94  0-R2  [SM0402_R]  40.39 63.5 180 top
RZ95  0-R2  [SM0402_R]  89.1 60.91 270 top
RZ96  0-R2  [SM0402_R]  40.39 62.23 180 top
RZ97  0-R2  [SM0402_R]  40.39 61.09 180 top
RZ98  0-R2  [SM0402_R]  78.66 59.59 0 top
RZ99  0-R2  [SM0402_R]  121.82 44.58 180 top
RZ100  0-R2  [SM0402_R]  75.13 53.54 0 bottom
RZ101  0-R2  [SM0402_R]  52.96 55.37 270 top
RZ102  0-R2  [SM0402_R]  54.1 55.37 270 top
RZ103  0-R2  [SM0402_R]  68.4 56.46 270 top
RZ104  0-R2  [SM0402_R]  131.57 54.99 0 top
RZ105  0-R2  [SM0402_R]  128.4 54.86 180 top
RZ106  0-R2  [SM0402_R]  56.64 52.32 270 top
RZ107  0-R2  [SM0402_R]  57.78 52.32 270 top
RZ108  0-R2  [SM0402_R]  51.38 53.54 180 top
RZ109  0-R2  [SM0402_R]  51 49.35 0 bottom
RZ110  0-R2  [SM0402_R]  51 50.5 0 bottom
RZ111  0-R2  [SM0402_R]  51 52.15 0 bottom
RZ112  0-R2  [SM0402_R]  119 42.85 0 top
RZ113  47K-R2  [SM0402_R]  120.02 88.14 180 top
RZ114  0-R2  [SM0402_R]  51 48.08 0 bottom
RZ115  0-R2  [SM0402_R]  139.34 44.45 270 top
RZ116  100K-R2  [SM0402_R]  115.98 84.96 180 bottom
RZ117  0-R2  [SM0402_R]  34.29 41.02 0 top
RZ118  47K-R2  [SM0402_R]  127.38 99.57 180 top
RZ119  0-R2  [SM0402_R]  116.66 42.85 0 top
RZ120  0-R2  [SM0402_R]  139.34 41.15 270 top
RZ121  100K-R2  [SM0402_R]  121.18 103.76 90 top
RZ122  0-R2  [SM0402_R]  36.7 40.01 90 top
RZ123  0-R2  [SM0402_R]  54.99 40.01 90 top
RZ124  0-R2  [SM0402_R]  80.09 40.06 90 top
RZ125  0-R2  [SM0402_R]  91.69 39.24 90 top
RZ126  0-R2  [SM0402_R]  116.92 40.18 90 top
RZ127  0-R2  [SM0402_R]  125.58 39.4 180 top
RZ128  0-R2  [SM0402_R]  30.61 35.59 90 top
RZ129  0-R2  [SM0402_R]  138.81 33.05 90 top
RZ130  0-R2  [SM0402_R]  47.37 32.66 90 top
RZ131  0-R2  [SM0402_R]  65.66 32.66 90 top
RZ132  0-R2  [SM0402_R]  83.95 32.66 90 top
RZ133  0-R2  [SM0402_R]  102.23 32.66 90 top
RZ134  0-R2  [SM0402_R]  120.52 32.66 90 top
RZ135  0-R2  [SM0402_R]  30.86 32.38 270 top
RZ136  0-R2  [SM0402_R]  138.94 29.84 270 top
RZ137  0-R2  [SM0402_R]  47.5 29.46 270 top
RZ138  0-R2  [SM0402_R]  65.79 29.46 270 top
RZ139  0-R2  [SM0402_R]  84.07 29.46 270 top
RZ140  0-R2  [SM0402_R]  102.36 29.46 270 top
RZ141  0-R2  [SM0402_R]  120.65 29.46 270 top
RZ142  0-R2  [SM0402_R]  157.48 183.26 180 bottom
RZ143  0-R2  [SM0402_R]  157.48 182.12 180 bottom
RZ144  0-R2  [SM0402_R]  157.48 177.93 180 bottom
RZ145  0-R2  [SM0402_R]  65.66 176.53 90 bottom
RZ146  0-R2  [SM0402_R]  157.48 176.91 180 bottom
RZ147  0-R2  [SM0402_R]  139.83 174.12 0 bottom
RZ148  0-R2  [SM0402_R]  64.26 173.99 180 top
RZ149  0-R2  [SM0402_R]  125.98 153.8 90 bottom
RZ150  0-R2  [SM0402_R]  124.84 153.8 270 bottom
RZ151  0-R2  [SM0402_R]  120.78 153.42 90 bottom
RZ152  0-R2  [SM0402_R]  119.63 153.42 270 bottom
RZ153  0-R2  [SM0402_R]  152.53 151.89 0 bottom
RZ154  0-R2  [SM0402_R]  152.53 150.75 0 bottom
RZ155  0-R2  [SM0402_R]  132.59 150.11 0 bottom
RZ156  0-R2  [SM0402_R]  140.08 149.99 270 bottom
RZ157  0-R2  [SM0402_R]  138.94 149.99 270 bottom
RZ158  0-R2  [SM0402_R]  137.79 149.99 270 bottom
RZ159  0-R2  [SM0402_R]  132.59 148.97 0 bottom
RZ160  0-R2  [SM0402_R]  152.53 148.08 0 bottom
RZ161  0-R2  [SM0402_R]  132.59 147.7 0 bottom
RZ162  0-R2  [SM0402_R]  152.53 146.94 180 bottom
RZ163  0-R2  [SM0402_R]  132.59 146.56 0 bottom
RZ164  0-R2  [SM0402_R]  148.84 146.18 180 bottom
RZ165  0-R2  [SM0402_R]  132.59 145.41 0 bottom
RZ166  0-R2  [SM0402_R]  148.84 141.35 90 bottom
RZ167  0-R2  [SM0402_R]  126.75 140.97 90 bottom
RZ168  0-R2  [SM0402_R]  146.69 139.06 270 bottom
RZ169  0-R2  [SM0402_R]  149.86 133.6 90 bottom
RZ170  0-R2  [SM0402_R]  143.13 133.35 0 bottom
RZ171  0-R2  [SM0402_R]  111.51 128.02 0 bottom
RZ172  0-R2  [SM0402_R]  143 121.21 90 bottom
RZ173  0-R2  [SM0402_R]  141.99 121.21 90 bottom
RZ174  0-R2  [SM0402_R]  145.16 121.16 90 bottom
RZ175  0-R2  [SM0402_R]  133.48 121.16 90 bottom
RZ176  0-R2  [SM0402_R]  132.46 121.16 90 bottom
RZ177  0-R2  [SM0402_R]  17.73 115.52 270 bottom
RZ178  0-R2  [SM0402_R]  147.12 112.67 180 bottom
RZ179  0-R2  [SM0402_R]  75.95 106.68 0 bottom
RZ180  0-R2  [SM0402_R]  50.29 105.56 180 bottom
RZ181  0-R2  [SM0402_R]  75.95 105.54 0 bottom
RZ182  0-R2  [SM0402_R]  50.29 104.52 0 bottom
RZ183  0-R2  [SM0402_R]  75.95 104.27 0 bottom
RZ184  0-R2  [SM0402_R]  75.95 103.12 0 bottom
RZ185  0-R2  [SM0402_R]  75.95 101.85 0 bottom
RZ186  0-R2  [SM0402_R]  75.95 100.71 0 bottom
RZ187  0-R2  [SM0402_R]  152.15 92.33 0 bottom
RZ188  0-R2  [SM0402_R]  152.15 91.19 0 bottom
RZ189  0-R2  [SM0402_R]  131.98 88.39 0 bottom
RZ190  0-R2  [SM0402_R]  152.15 90.04 0 bottom
RZ191  0-R2  [SM0402_R]  115.98 86.11 180 bottom
RZ192  0-R2  [SM0402_R]  112.55 85.98 90 bottom
RZ193  0-R2  [SM0402_R]  42.7 80.39 90 bottom
RZ194  0-R2  [SM0402_R]  37.54 86.92 0 bottom
RZ195  0-R2  [SM0402_R]  73.69 83.44 270 bottom
RZ196  0-R2  [SM0402_R]  70.13 84.05 180 bottom
RZ197  0-R2  [SM0402_R]  70.82 79.96 180 bottom
RZ198  0-R2  [SM0402_R]  68.66 79.96 0 bottom
RZ199  0-R2  [SM0402_R]  139.34 75.82 270 bottom
RZ200  0-R2  [SM0402_R]  6.6 72.52 90 top
RZ201  0-R2  [SM0402_R]  141.1 73.15 0 bottom
RZ202  0-R2  [SM0402_R]  7.75 72.52 90 top
RZ203  0-R2  [SM0402_R]  141.1 72.01 0 bottom
RZ204  0-R2  [SM0402_R]  143.41 67.31 180 bottom
RZ205  0-R2  [SM0402_R]  128.47 67.01 0 bottom
RZ206  0-R2  [SM0402_R]  128.47 65.86 0 bottom
RZ207  0-R2  [SM0402_R]  65.48 52.27 270 bottom
RZ208  0-R2  [SM0402_R]  66.62 52.27 270 bottom
RZ685  33-R2  [SM0402_R]  147.96 152.78 90 bottom
RZ686  33-R2  [SM0402_R]  147.96 154.94 90 bottom
RZ687  @0-R2  [SM0402_R]  15.88 107.06 90 top
RZ688  @0-R2  [SM0402_R]  66.8 176.53 90 bottom
RZU1  @0-R2  [SM0402_R]  33.35 191.85 90 top
RZU2  @0-R2  [SM0402_R]  34.49 191.85 90 top
RZU3  @0-R2  [SM0402_R]  130.18 163.07 0 top
RZU4  @0-R2  [SM0402_R]  112.14 158.75 180 top
RZU5  @0-R2  [SM0402_R]  114.3 156.84 90 top
RZU6  @0-R2  [SM0402_R]  48.9 139.57 0 top
RZU7  @0-R2  [SM0402_R]  97.16 138.94 270 top
RZU8  @0-R2  [SM0402_R]  119.51 133.99 270 top
RZU9  @0-R2  [SM0402_R]  120.65 133.99 90 top
RZU10  @0-R2  [SM0402_R]  137.54 127.13 270 top
RZU11  @0-R2  [SM0402_R]  138.68 127.13 270 top
RZU12  @0-R2  [SM0402_R]  139.83 127.13 270 top
RZU13  @0-R2  [SM0402_R]  131.57 126.87 0 top
RZU14  @0-R2  [SM0402_R]  133.73 126.87 0 top
RZU15  @0-R2  [SM0402_R]  135.89 126.87 0 top
RZU16  @0-R2  [SM0402_R]  144.4 126.97 270 top
RZU17  @0-R2  [SM0402_R]  141.48 126.62 180 top
RZU18  @0-R2  [SM0402_R]  131.57 125.86 0 top
RZU19  @0-R2  [SM0402_R]  7.44 109.8 0 top
RZU20  @0-R2  [SM0402_R]  95.12 108.97 90 top
RZU21  @0-R2  [SM0402_R]  73.81 109.09 90 top
RZU22  @0-R2  [SM0402_R]  145 108.72 270 top
RZU23  @0-R2  [SM0402_R]  146.14 108.72 270 top
RZU24  @0-R2  [SM0402_R]  95.02 106.05 90 top
RZU25  @0-R2  [SM0402_R]  39.45 101.3 0 top
RZU26  @0-R2  [SM0402_R]  87.66 92.71 270 top
RZU27  @0-R2  [SM0402_R]  39.45 91.64 0 top
RZU28  @0-R2  [SM0402_R]  89.31 80.9 270 bottom
RZU29  @0-R2  [SM0402_R]  74.04 79.63 0 top
RZU30  @0-R2  [SM0402_R]  122.81 77.34 90 top
RZU31  @0-R2  [SM0402_R]  126.14 71.37 90 top
RZU32  @0-R2  [SM0402_R]  61.67 71.45 0 top
RZU33  @0-R2  [SM0402_R]  61.67 70.31 0 top
RZU34  @0-R2  [SM0402_R]  73.74 64.47 0 top
RZU35  @0-R2  [SM0402_R]  74.12 55.32 180 top
RZU36  @0-R2  [SM0402_R]  53.75 48.87 90 bottom
RZU37  @0-R2  [SM0402_R]  149.99 151.89 0 bottom
RZU38  @0-R2  [SM0402_R]  112.29 151.76 0 bottom
RZU39  @0-R2  [SM0402_R]  149.99 150.75 180 bottom
RZU40  @0-R2  [SM0402_R]  147.57 133.6 90 bottom
RZU41  @0-R2  [SM0402_R]  146.43 133.6 90 bottom
RZU42  @0-R2  [SM0402_R]  140.97 133.35 180 bottom
RZU43  @0-R2  [SM0402_R]  50.29 107.95 180 bottom
RZU44  @0-R2  [SM0402_R]  50.29 106.81 180 bottom
RZU45  @0-R2  [SM0402_R]  103.63 86.36 180 bottom
RZU46  @0-R2  [SM0402_R]  35.43 72.92 180 bottom
RZU47  @0-R2  [SM0402_R]  35.43 74.19 180 bottom
S2  @0402SHORT  [SHORT-0402]  72.72 108.03 270 top
S3  @0402SHORT  [SHORT-0402]  74.37 90.55 180 top
S4  @0402SHORT  [SHORT-0402]  53.29 107.01 270 top
S5  @0402SHORT  [SHORT-0402]  53.87 84.84 90 top
S6  @0402SHORT  [SHORT-0402]  133.25 89.66 0 top
S8  @SHORT-0603  [SHORT-0603]  134.82 107.49 0 bottom
SPI1  MX25V2035FM1Q6862023301017P  [SOP8_W150P127H18]  68.83 77.85 90 top
SPI2  MX25V2035FM1Q6862023301017P  [SOP8_W150P127H18]  50.75 47.57 90 top
SSD2  NGFF-75P,H8.5-M  [M2-67H85-M-2280]  146.81 113.65 0 top
SW1  SW-STS-05-A  [SWTS5X5_STS05]  120.4 44.7 0 bottom
SW2  SW-STS-05-A  [SWTS5X5_STS05]  114.3 44.7 180 bottom
TH1  NLC2K06SMF  [SMF]  146.18 44.2 90 top
TH2  NLC2K06SMF  [SMF]  146.18 49.28 90 top
TH3  NLC2K06SMF  [SMF]  146.18 54.36 90 top
TH4  NLC2K06SMF  [SMF]  146.18 59.44 90 top
TP1  @LABTESTPOINT  [TP30T]  87.27 132.7 180 bottom
TP2  @LABTESTPOINT  [TP30T]  87.83 128.26 180 bottom
TP3  @LABTESTPOINT  [TP30T]  87.81 126.79 180 bottom
TP4  @LABTESTPOINT  [TP30T]  87.88 122.24 180 bottom
TP5  @LABTESTPOINT  [TP30T]  88.54 119.89 180 bottom
TP6  @LABTESTPOINT  [TP30T]  106.55 126.75 180 bottom
TP7  @LABTESTPOINT  [TP30T]  106.43 123.7 180 bottom
TP8  @LABTESTPOINT  [TP30T]  105.79 125.22 180 bottom
TP9  @LABTESTPOINT  [TP30T]  107.95 123.7 180 bottom
TP10  @LABTESTPOINT  [TP30T]  107.06 125.22 180 bottom
TP11  @TP  [TP30T]  100.38 129.76 180 bottom
TP12  @LABTESTPOINT  [TP30T]  133.6 156.72 180 top
TP13  @LABTESTPOINT  [TP30T]  131.06 154.69 180 top
TP14  @LABTESTPOINT  [TP30T]  130.3 153.54 180 top
TP15  @LABTESTPOINT  [TP30T]  133.6 159.77 180 top
TP16  @LABTESTPOINT  [TP30T]  133.6 158.37 180 top
TP17  @LABTESTPOINT  [TP30T]  125.22 160.27 180 top
TP18  FPC-8P-P0.5-DOWN-RA-S-A  [FPC8P05_51540]  153.57 12.87 180 bottom
TP19  @LABTESTPOINT  [TP30T]  43.81 123.06 0 top
TP20  @LABTESTPOINT  [TP30T]  42.8 113.54 0 top
TP21  @LABTESTPOINT  [TP30T]  42.55 123.06 0 top
TP22  @LABTESTPOINT  [TP30T]  41.27 113.54 0 top
TP23  @LABTESTPOINT  [TP30T]  39.88 113.54 0 top
TP24  @LABTESTPOINT  [TP30T]  136.65 148.46 90 bottom
TP25  @LABTESTPOINT  [TP30T]  136.65 147.19 90 bottom
TP26  @LABTESTPOINT  [TP30T]  136.65 144.65 90 bottom
TP27  @LABTESTPOINT  [TP30T]  136.65 145.92 90 bottom
TP28  @LABTESTPOINT  [TP30T]  138.68 151.89 90 bottom
TP29  @LABTESTPOINT  [TP30T]  137.41 151.89 90 bottom
TP30  @LABTESTPOINT  [TP30T]  121.51 120.47 270 top
TP31  @LABTESTPOINT  [TP30T]  125.86 123.95 270 bottom
TP32  @LABTESTPOINT  [TP30T]  125.86 126.36 270 bottom
TP33  @LABTESTPOINT  [TP30T]  114.78 118.24 270 top
TP34  @LABTESTPOINT  [TP30T]  117.73 125.09 270 bottom
TP35  @TP  [TP20T]  76.33 152.91 0 top
TP36  @TP  [TP20T]  75.18 152.91 0 top
TP37  @TP  [TP20T]  74.04 152.91 0 top
TP38  @TP  [TP20T]  76.5 160.05 0 top
TP39  @TP  [TP20T]  141.99 132.33 180 bottom
TP40  @TP  [TP20T]  156.84 175.64 180 bottom
TP41  @TP  [TP20T]  156.84 180.59 180 bottom
TP42  @TP  [TP20T]  157.99 180.59 180 bottom
TP43  @TP  [TP20T]  157.1 192.91 180 bottom
TP44  @TP  [TP20T]  146.56 193.04 180 bottom
TP45  @TP  [TP20T]  157.1 194.18 180 bottom
TP47  @TP  [TP20T]  69.6 86 90 top
TP48  @TP  [TP20T]  73.56 88.11 90 top
TP49  @TP  [TP20T]  51.89 56.08 270 top
TP50  @LABTESTPOINT  [TP30T]  118.14 101.6 90 bottom
TP51  @LABTESTPOINT  [TP30T]  129.95 107.31 90 top
TP52  @LABTESTPOINT  [TP30T]  121.03 162.56 0 top
TP53  @LABTESTPOINT  [TP30T]  122.43 162.56 0 top
TP54  @LABTESTPOINT  [TP30T]  121.16 173.99 0 top
TP55  @LABTESTPOINT  [TP30T]  122.43 173.99 0 top
TP56  @LABTESTPOINT  [TP30T]  129.67 154.69 180 top
TP57  @LABTESTPOINT  [TP30T]  132.46 154.69 180 top
TP58  @LABTESTPOINT  [TP30T]  131.7 153.54 180 top
TP59  @LABTESTPOINT  [TP30T]  132.33 160.53 180 top
TP60  @LABTESTPOINT  [TP30T]  56.77 192.02 0 top
U3  SN74LVC1G08DRLR  [SOT553]  48.21 111.33 180 top
U4  SN74LVC1G08DRLR  [SOT553]  108.46 139.19 0 top
U5  SN74LVC1G08DRLR  [SOT553]  51.08 111.28 180 top
U6  EFM8SB10F8G-A-QFN20  [QFN20_3X3P05H08-TH67]  130.78 157.57 180 top
U7  SN74LVC1T45DCKR  [SOT363]  130.18 164.97 270 top
U9  SN74LVC1G32DCK  [SOT353]  92.71 106.3 90 top
U10  SN74AUP1G07DCK  [SOT353]  109.2 152.47 0 top
U11  74LVC1G08GW,125  [SOT353]  109.21 156.28 0 top
U12  SN74LVC1G32DCK  [SOT353]  83.21 105.66 270 top
U13  LPC54113J128BD64QL  [LQFP64_10X10P05H16]  137.58 70.05 180 top
U14  TCA6408A  [TQFN16_2D6X1D8P04H06]  124.65 74.06 270 top
U15  AT24C02D-SSHM-T  [SOP8_W150P127H18]  41.95 118.27 0 top
U16  ALC5640-VB-CG  [QFN48_6X6P04H10-TH173]  141.35 144.78 180 bottom
U18  SLB9672XU2.0,FW16.13  [QFN32_5X5P05H06-TH142]  110.07 85.75 90 top
U19  SN74LVC1G08DRLR  [SOT553]  113.06 90.93 180 top
U20  GL3590-OTY20  [QFN76_9X9P04H09-TH252]  82.42 66.55 180 top
U21  MX25V20066M1I02-6894003301000P  [SOP8_W150P127H18]  81.66 78.11 270 top
U22  MIC2039AYM6  [SOT23-6]  94.82 59.89 270 top
U23  MIC2039AYM6  [SOT23-6]  78.69 52.27 90 bottom
U24  ADUM242E0WBRWZ  [SOP16_W300P127H27]  90.2 184.28 0 top
U25  F81534U  [TQFP64_7X7P04H12]  82.68 156.84 270 top
U26  ADUM242E0WBRWZ  [SOP16_W300P127H27]  90.2 184.28 180 bottom
U27  RDL03-24S05W  [DIPICS6P_RDL03W]  77.93 173.53 90 bottom
U29  OSC-32.768KHZ-3.2X2.5-S-WT  [OSC3225]  139.06 135.13 0 top
U30  TPS22992SRXNR  [QFN8_1D25X1D5P05H08]  128.91 141.1 270 bottom
U32  TPS22992SRXNR  [QFN8_1D25X1D5P05H08]  140.72 177.16 0 bottom
U33  SN74LVC1G126DCK  [SOT353]  117.09 134.24 270 top
U34  MPM3810GQB-Z  [QFN12_2D5X3P04H10_MPS]  130.09 176.88 270 top
U36  MAX22025AWA+  [SOP8_W200P127H22]  65.01 182.68 0 top
U38  MAX22025AWA+  [SOP8_W200P127H22]  65.02 182.63 180 bottom
U39  RDL03-24S12W-D  [DIPICS6P_RDL03W]  51.64 173.61 90 bottom
U40  XISOW1050VDWER  [SOP16_W300P127H27]  33.73 184.51 0 top
U41  WGI210IT  [QFN64_9X9P05H10-TH142]  24.56 32.89 0 bottom
U42  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  17.4 37.97 180 top
U43  WGI210IT  [QFN64_9X9P05H10-TH142]  41.33 29.97 0 bottom
U44  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  34.16 35.05 180 top
U45  WGI210IT  [QFN64_9X9P05H10-TH142]  59.61 29.97 0 bottom
U46  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  52.45 35.05 180 top
U47  WGI210IT  [QFN64_9X9P05H10-TH142]  77.9 29.97 0 bottom
U48  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  70.74 35.05 180 top
U49  WGI210IT  [QFN64_9X9P05H10-TH142]  96.19 29.97 0 bottom
U50  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  89.03 35.05 180 top
U51  WGI210IT  [QFN64_9X9P05H10-TH142]  114.48 29.97 0 bottom
U52  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  107.31 35.05 180 top
U53  WGI210IT  [QFN64_9X9P05H10-TH142]  132.77 30.35 0 bottom
U54  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  125.6 35.43 180 top
U55  WGI210IT  [QFN64_9X9P05H10-TH142]  131.06 48.82 90 bottom
U56  MX25V80066ZUI02  [DFN8_2X3P05H06-TH10X63]  125.98 41.66 270 top
U57  L22T002-4  [TF-18D1X12D2X6D2P127-24P]  18.29 14.15 0 bottom
U58  L22T002-2  [TF-L22T0022-24P]  39.88 13.46 0 bottom
U59  L22T002-2  [TF-L22T0022-24P]  60.07 13.46 0 bottom
U60  L22T002-2  [TF-L22T0022-24P]  80.26 13.46 0 bottom
U61  L22T002-2  [TF-L22T0022-24P]  100.46 13.46 0 bottom
U62  L22T002-2  [TF-L22T0022-24P]  120.65 13.46 0 bottom
U63  L22T002-2  [TF-L22T0022-24P]  140.84 13.46 0 bottom
U64  L22T003-0  [TF-L22T0030-24P]  145.59 50.04 90 bottom
U65  TPS23881B1RTQR  [QFN56_8X8P05H10-TH224]  14.51 75.25 0 top
U66  EP9633C-YELLOW  [QFN64_8X8P04H09-TH256]  95.29 85.93 0 top
U67  ASM1812  [BGA492_21X21P08H15]  63.16 96.22 270 bottom
U70  ASM1806  [QFN88_10X10P04H10-TH]  53.56 65.26 90 top
U72  MUN3CAD03-SF  [QFN10_3X3H13_MUN3CA]  42.97 93.57 0 top
U73  MUN3CAD03-SF  [QFN10_3X3H13_MUN3CA]  42.97 103.22 0 top
U74  LM74700QDBVRQ1  [SOT23-6]  20.85 180.97 0 bottom
U75  MIC842NYC5  [SOT353]  56.77 169.16 0 top
U76  MPQ8633BGLE-Z  [QFN21_3X4PH10_MPS]  135.38 85.34 270 bottom
U77  MP8759GD  [QFN12_2X3P05H10_MPS]  144.15 96.27 180 bottom
U78  MUN3CAD03-SF  [QFN10_3X3H13_MUN3CA]  84.86 99.16 270 bottom
U79  MUN3CAD03-SF  [QFN10_3X3H13_MUN3CA]  84.86 92.86 180 bottom
U80  TPS22992SRXNR  [QFN8_1D25X1D5P05H08]  93.5 100.18 0 top
U81  TPS22992SRXNR  [QFN8_1D25X1D5P05H08]  99.16 96.11 0 top
U83  LM51770QDCPRQ1  [TSSOP38_W170P05H12-TH134X382]  13.94 112.5 90 top
U84  OSC-32.768KHZ-3.2X2.5-S-WT  [OSC3225]  154.4 100.09 0 top
U85  TXB0304RUT  [TQFN12_2X1D7P04H06]  140.97 103.76 0 bottom
U86  SN74AVC4T245RSVR  [TQFN16_2D6X1D8P04H06]  109.47 95.76 180 top
U87  PCA9306DCUR  [VSSOP8_W90P05H09]  124.85 65.72 0 bottom
U88  SN74LVC2G17DCKR  [SOT363]  119.25 107.06 0 top
U89  SN74LVC2G17DCKR  [SOT363]  116.08 107.06 0 top
U90  SN74LVC2G17DCKR  [SOT363]  83.19 109.17 90 top
U91  SN74LVC1G32DCK  [SOT353]  92.64 109.38 90 top
U92  LM5145QRGYRQ1  [QFN20_4D5X3D5P05H10-TH67X106]  50.55 147.07 180 top
UART1  WF200-12/B12B-PASK(LF)(SN)  [WF200D-12P-PASK]  76.14 197.59 180 bottom
UNK@U28  MIC2039AYM6  [SOT23-6]  69.67 53.59 90 top
USB1  WF200-10/2005-2WS-10-LF  [WF200D-5X2P-CI01]  64.65 44.87 180 bottom
VS1  @VIRTUAL_SHORT  [SHORT_25X40]  151.46 142.57 180 top
VS2  @VIRTUAL_SHORT  [SHORT_25X40]  138.81 144.02 180 top
VS3  @VIRTUAL_SHORT  [SHORT_25X40]  140.46 142.37 270 top
VS4  @VIRTUAL_SHORT  [SHORT_25X40]  142.24 142.37 270 top
VS5  @VIRTUAL_SHORT  [SHORT_25X40]  151.51 142.7 180 bottom
WIFI1  NGFF-75P,H4.0-E  [M2-67H40-E-2230]  141.49 128.65 0 bottom
WOL1  PH254-2X1  [CONHD2X1]  157.61 171.7 270 bottom
X1  25MHZ-2016-S-WT  [XTAL2016-4]  94.74 66.8 90 top
X2  25MHZ-2016-S-WT  [XTAL2016-4]  32 26.8 0 bottom
X3  25MHZ-2016-S-WT  [XTAL2016-4]  48.77 23.88 0 bottom
X4  25MHZ-2016-S-WT  [XTAL2016-4]  67.06 23.88 0 bottom
X5  25MHZ-2016-S-WT  [XTAL2016-4]  85.34 23.88 0 bottom
X6  25MHZ-2016-S-WT  [XTAL2016-4]  103.63 23.88 0 bottom
X7  25MHZ-2016-S-WT  [XTAL2016-4]  121.92 23.88 0 bottom
X8  25MHZ-2016-S-WT  [XTAL2016-4]  140.08 24.26 0 bottom
X9  25MHZ-2016-S-WT  [XTAL2016-4]  134.19 58.62 180 bottom
X10  25MHZ-2016-S-WT  [XTAL2016-4]  70.99 110.62 180 bottom
X11  25MHZ-2016-S-WT  [XTAL2016-4]  43.64 70.56 90 top
Y1  12MHZ-3.2X2.5-S-WT  [XTAL3225-4]  72.9 156.08 270 top
Y2  24MHZ-3225-S  [XTAL3225-4]  92.08 95.76 180 top
Z1  ESD-2P-C2  [SM0402_V]  150.14 70.1 180 top
Z2  ESD-2P-C2  [SM0402_V]  153.14 16.54 270 bottom
Z3  ESD-2P-C2  [SM0402_V]  151.87 16.54 270 bottom
Z4  ESD-2P-C2  [SM0402_V]  150.6 16.54 270 bottom
Z5  ESD-2P-C2  [SM0402_V]  150.14 71.63 180 top
Z6  ESD-2P-C2  [SM0402_V]  150.14 74.3 180 top
Z7  ESD-2P-C2  [SM0402_V]  117.35 153.42 90 bottom
Z8  ESD-2P-C2  [SM0402_V]  117.09 132.21 0 top
Z9  ESD-2P-C2  [SM0402_V]  122.56 153.8 90 bottom
Z10  ESD-2P-C2  [SM0402_V]  138.81 42.8 0 top
Z12  ESD-2P-C2  [SM0402_V]  46.48 139.57 0 top
Z16  ESD-2P-C2  [SM0402_V]  157.61 25.53 0 bottom
Z17  ESD-2P-C2  [SM0402_V]  145.29 172.72 90 bottom
Z18  ESD-2P-C2  [SM0402_V]  121.79 136.14 270 top

## Library data of the parts
AUDIO1 = AUDIO_2X5_2mm_BOX: room: AUDIO
AUTOPW1 WOL1 = HEADER_6: room: EEPROM
BAT1 = W-1X4-2_0.54MM: room: CVM
BUZZ1 = 4 HEADER_1: room: TPM-JTAG-BUZ
C1 C2 = C#1: tolerance: 20%; signal model: nv_cap; room: CVM
C10 C894 = C_0: tolerance: 20%; signal model: nv_cap; room: BTNMCU
C18-C25 CA69 CA149-CA152 CA248 = C0402: room: MCU2
C27 C30 C34 C35 C38 C40 C42 C43 C45 C54 CA51 CA52 CA54 CA130-CA132 CA134 = C#1: tolerance: 10%; signal model: ?; room: AUDIO
C44 C898 C899 = C_0: tolerance: 20%; signal model: nv_cap; room: AUDIO
C46 C47 = C_0: tolerance: 10%; room: AUDIO
C57-C62 C499 C910-C916 CA21 CA24 CA247 = 0_0.1U/16V/X7R-C2: room: USBHUB
C63-C68 CA74-CA79 CA82 CA84 = CAP: room: USB31
C69 C70 CA1 CA2 CA10 CA19 CA118 CA122 CB5 = C0402: room: USB2COM
C71 C900-C909 = CAP: room: USB2COM
C72 C73 = CAP NP: room: USB2COM
C74 C78 = CAPC-SM1808-1KV_2: room: USB2COM
C75 C79 = C0603: room: USB2COM
C76 = C-0603_1: room: USB2COM
C77 = C1206: room: USB2COM
C80 CA83 = CAP: room: USB-C
C81 C83 C88 C90 = C0805_1: room: M2E
C82 C84 C87 C89 C92 CA57 CA58 CM65-CM67 = C0402: room: M2E
C91 = CAP: room: M2E
C110-C113 C117-C121 C123-C126 C128 C129 CA4 CA6 CA9 CA12 CA120 = CAP: room: M2B
C130 CM64 = C0402: room: M2B
C132 C134 C135 = 0_0.1U/16V/Y5V-C2: room: BUTTON
C136-C140 = C0402: room: CAMERA
C141 C142 CA13 CA18 CA121 = CAP: room: CAMERA
C143 = 0_0.1U/16V/Y5V-C2: room: CAMERA
C155 C158 = CAPC-SM1808-1KV_2: room: ISOCAN
C156 C157 = C1206: room: ISOCAN
C159 C160 = C0603: room: ISOCAN
C162-C164 CA7 CA8 = 0_0.1U/16V/X7R-C2: room: ISOCAN
C166-C170 C172 = C0603_0: room: GLAN1
C171 CM81 CM82 = C0402: room: GLAN1
C173 C174 = 0_0.1U/16V/X7R-C2: room: GLAN1
C175-C179 C181 = C0603_0: room: GLAN2
C180 CM93 CM94 = C0402: room: GLAN2
C182 C183 = 0_0.1U/16V/X7R-C2: room: GLAN2
C184-C188 C190 = C0603_0: room: GLAN3
C189 CM91 CM92 = C0402: room: GLAN3
C191 C192 = 0_0.1U/16V/X7R-C2: room: GLAN3
C193-C197 C199 = C0603_0: room: GLAN4
C198 CM89 CM90 = C0402: room: GLAN4
C200 C201 = 0_0.1U/16V/X7R-C2: room: GLAN4
C202-C205 C207 C208 = C0603_0: room: GLAN5
C206 CM87 CM88 = C0402: room: GLAN5
C209 C210 = 0_0.1U/16V/X7R-C2: room: GLAN5
C211-C215 C217 = C0603_0: room: GLAN6
C216 CM85 CM86 = C0402: room: GLAN6
C218 C219 = 0_0.1U/16V/X7R-C2: room: GLAN6
C220-C224 C226 = C0603_0: room: GLAN7
C225 CM83 CM84 = C0402: room: GLAN7
C227 C228 = 0_0.1U/16V/X7R-C2: room: GLAN7
C229-C233 C235 = C0603_0: room: GLAN8
C234 CM79 CM80 = C0402: room: GLAN8
C236 C237 = 0_0.1U/16V/X7R-C2: room: GLAN8
C238 C240-C242 C244-C247 = CAP: room: POE12
C239 C243 CA89-CA96 = C-0603-0.1U: room: POE12
C248 C253 CA97-CA104 = C-0603-0.1U: room: POE34
C249-C252 C254-C257 = CAP: room: POE34
C258 C263 CA105-CA112 = C-0603-0.1U: room: POE56
C259-C262 C264-C267 = CAP: room: POE56
C268 C273 CA81 CA85-CA87 CA113-CA116 = C-0603-0.1U: room: POE78
C269-C272 C274-C277 = CAP: room: POE78
C279 = C: room: POECTL
C280-C287 = CAP NP_6: room: POEMFET
C288-C291 C293 C295-C317 CB20-CB28 CB155-CB162 = CAP NP: room: HDMI
C292 = CAP NP_3: room: HDMI
C294 = C0603: room: HDMI
C318 CM32-CM43 CM46-CM49 CM68-CM71 CM73-CM78 = C0402: room: ASM1812
C319 = 0_0.1U/16V/X7R-C2: room: ASM1812
C323 C324 C326 C327 C329 C330 = 0_0.1U/16V/Y5V-C2: room: ASM1812
C332 C333 C335-C364 CB15-CB18 CB29 = C0201_0: room: ASM1812
C369 C370 CM50-CM63 = C0402: room: ASM1806
C371 = 0_0.1U/16V/X7R-C2: room: ASM1806
C374-C377 C380 C385 CM2-CM24 = C0402: room: ASM_PWR
C378 C379 C381-C384 C386 C387 = 0_0.1U/16V/Y5V-C2: room: ASM_PWR
C388 = CAP NP_6: room: DCIN
C389-C393 C918-C921 = C: room: DCIN
C394 = C0402_2: room: DCIN
C395-C397 C400 C405 C406 = C0402: room: 5VSB_S
C398 C399 = C0402_5: room: 5VSB_S
C401-C404 = C0402_4: room: 5VSB_S
C407 = C0402_2: room: 5VSB_S
C409 C410 = C0805_0: room: 3V3SB_S
C412-C415 C418 = CAP: room: 3V3SB_S
C417 CM72 = C0402: room: 3V3SB_S
C419 = C0402_2: room: 3V3SB_S
C420-C423 C425 C426 C428 C429 = 0_0.1U/16V/Y5V-C2: room: 1V8SB_1V2SB
C424 C427 C432 C434 CM44 CM45 = C0402: room: 1V8SB_1V2SB
C430 C431 = CAP: room: 1V8SB_1V2SB
C436-C444 C446-C458 = C: room: V12SB
C459 C460 C462 C466 C467 C469-C477 C917 C922 = C: room: POEPWR
C463-C465 C468 = CAP NP_6: room: POEPWR
C479 C481 C486 = C0805_1: room: M2M
C480 C482 C483 C487 C488 CA137-CA139 CM1 CM25-CM31 = C0402: room: M2M
C838 C839 = C0402: room: AUDIO
C891 = CAP: room: EEPROM
C892 = C-0603: room: EEPROM
CA3 CA17 = C0402: room: ISOCAN
CA5 CA11 CA119 CA124 = 0_0.1U/16V/X7R-C2: room: ISO422
CA14-CA16 = C0402: tolerance: 10%; room: AUDIO
CA20 CA22 CA23 CA25-CA44 CA246 = C0201_0: room: USBHUB
CA45 = C0402: tolerance: 10%; room: DCIN
CA46 CA61 CA125 CA140-CA143 = C#1: tolerance: 10%; signal model: nv_cap; room: BTNMCU
CA47 CA126 CA129 = C_0: tolerance: 10%; signal model: nv_cap; room: BTNMCU
CA48 CA50 CA70 CA71 = C-0603: room: DIO
CA49 CA127 CA128 = C0402: tolerance: 10%; room: USB2COM
CA53 = C: tolerance: 10%; room: V12SB
CA55 = C0402: tolerance: 10%; room: M2E
CA56 = C_0: tolerance: 10%; signal model: nv_cap; room: EEPROM
CA59 = C#1: tolerance: 10%; signal model: nv_cap; room: EEPROM
CA60 CA64 = C: tolerance: 10%; room: POEPWR
CA62 CA63 = CAP: room: CVM
CA65 = C0402: tolerance: 10%; room: M2M
CA66 CA67 CA147 = C0402: tolerance: 10%; room: 5VSB_S
CA68 = C: tolerance: 10%; room: POECTL
CA72 CA73 CA80 = 0_0.1U/16V/X7R-C2: room: ASM_PWR
CA88 = C0201_0: room: ASM1806
CA117 = C-0603: room: TPM-JTAG-BUZ
CA133 CA135 CA153 = C0402: room: BUTTON
CA136 = C#1: tolerance: 10%; signal model: nv_cap; room: TPM-JTAG-BUZ
CA144 CA145 = C0402: room: CVM
CA146 = C0402: tolerance: 10%; room: 3V3SB_S
CA148 = C0402: tolerance: 10%; room: CVM
CAMMH1-CAMMH3 NVMH1-NVMH4 OOBMH1-OOBMH3 = STAND OFF_0: room: HOLE
CB1 CB12 CB13 CB19 = C0201_0: room: TPM-JTAG-BUZ
CB2-CB4 = C0201_0: room: CVM
CB6-CB9 = CAP: room: ASM_PWR
CB10 CB11 = C0201_0: room: 1V8SB_1V2SB
CB14 CB136 = C0201_0: room: 3V3SB_S
CB30-CB42 CB139 CB140 = C0201_0: room: GLAN8
CB43-CB45 CB49 CB65 CB66 CB79 CB80 CB87-CB91 CB141 CB148 = C0201_0: room: GLAN1
CB46-CB48 CB67 CB73 CB81 CB92 CB98 CB104-CB108 CB142 CB149 = C0201_0: room: GLAN7
CB50 CB51 CB60 CB68 CB74 CB82 CB93 CB99 CB109-CB112 CB129 CB147 CB154 = C0201_0: room: GLAN2
CB52 CB53 CB61 CB69 CB75 CB83 CB94 CB100 CB113-CB116 CB130 CB146 CB153 = C0201_0: room: GLAN3
CB54 CB55 CB62 CB70 CB76 CB84 CB95 CB101 CB117-CB120 CB131 CB145 CB152 = C0201_0: room: GLAN4
CB56 CB57 CB63 CB71 CB77 CB85 CB96 CB102 CB121-CB124 CB132 CB144 CB151 = C0201_0: room: GLAN5
CB58 CB59 CB64 CB72 CB78 CB86 CB97 CB103 CB125-CB128 CB133 CB143 CB150 = C0201_0: room: GLAN6
CB134 = C0201_0: room: M2B
CB135 = C0201_0: room: M2E
CB137 CB138 = 0_0.1U/16V/X7R-C2: room: TPM-JTAG-BUZ
CE1 = CE-10: room: ISOCAN
CE2 = ECAP: room: M2B
CE3-CE5 = CE-10: room: DCIN
CE6 CE7 = CE-10: room: POEPWR
CE8 = CE-10_4: room: 3V3SB_S
CE9 CE10 = CE-10_4: room: 5VSB_S
CE11 CE12 = CE-10_4: room: USB31
CE13 = CE-10_4: room: USB-C
CN1 = CONN-USBX1-UPRIGHT_0: room: USB31
CN2 = CONN-USBX1-UPRIGHT_2: room: USB31
CV1 = C-1206: room: POE12
CV8 = C-1206: room: POE78
D1 = BAT54C_1: room: CVM
D2 D65 = 1N5817_0: room: BTNMCU
D5 D7 D8 = LF9209A_6: room: USB31
D9 D10 = LF9209A_6: room: USB2COM
D11 D66 = LF9209A_6: room: USB-C
D12 D13 = V-PORT-220-V05_0: room: ISOCAN
D14 D15 D17 D18 D20 D22 = DIODE TVS BI-DIR_0: room: POE12
D16 D19 D21 D23 = LF9209A_6: room: POE12
D24 D27 D29 D31 = LF9209A_6: room: POE34
D25 D26 D28 D30 = DIODE TVS BI-DIR_0: room: POE34
D32 D35 D37 D39 = LF9209A_6: room: POE56
D33 D34 D36 D38 = DIODE TVS BI-DIR_0: room: POE56
D40 D41 = DIODE TVS BI-DIR_0: room: POE78
D42-D45 = LF9209A_6: room: POE78
D46-D53 = DFLS160_0: room: POEMFET
D54 = SCHOTTKY: room: HDMI
D55-D57 = LF9209A_6: room: HDMI
D58 = VDIODE_1: room: DCIN
D59-D63 = DIODE-ZENER_2: room: DCIN
D64 = 1N5817_0: room: 3V3SB_S
DB1 = JFRT2_0: room: MCU2
DC_IN1 = CONN-ATX_0: room: DCIN
F1-F8 = MINI-SMDC110_0: room: POEMFET
F9 = FUSE: room: HDMI
FB1 FB46 = FB0603_0: room: MCU2
FB2 = L: room: MCU2
FB3 = FER_BEAD: room: USBHUB
FB5 = FB0402: room: M2E
FB7 = L: room: M2B
FB8-FB13 = FER_BEAD: room: POE12
FB16-FB19 = FER_BEAD: room: POE34
FB20-FB23 = FER_BEAD: room: POE56
FB26 FB27 = FER_BEAD: room: POE78
FB28-FB34 = RESISTOR_0: room: HDMI
FB35-FB37 = FER_BEAD: room: ASM_PWR
FB38 = FB0603_0: room: DCIN
FB39 = FB0402: room: M2M
FB40 FB41 = 80,3A_1: room: AUDIO
FB47-FB50 = FER_BEAD: room: POE4
FL1 = FILTER USB2_3.0: room: M2B
FL2 = FILTER USB2_0.0: room: ISOCAN
H1-H4 = Mounting Hole_0: room: HOLE
HDMI1 = CON-19-HDMI-NS-J_0: room: HDMI
J1 = CON_B2B_0: room: CVM
J4 = HDR_2X5: room: TPM-JTAG-BUZ
J7 = HEADER_0: room: HDMI
J11 = JUMPER_1X3P_YELLOW_0: room: ASM1812
J13 = JUMPER_1X3P_YELLOW_0: room: ASM1806
J14 = CON_B2B_1: room: CAMERA
JPPCIE1 = HEADER_6: room: ASM_PWR
JPSON1 = HEADER_6: room: 3V3SB_S
JSIM1 JSIM2 = SIMS-FIT-WL41D67-E2002-7H_0: room: M2B
L1 L2 L7 = FILTER USB2_2.0: room: USB31
L3-L6 = FILTER USB2_0.0: room: USB31
L8-L11 = FILTER USB2_1.0: room: HDMI
L12 = INDUCTOR_0: room: POEPWR
LANACT1 = LED_2: room: GLAN1
LANACT2 = LED_2: room: GLAN2
LANACT3 = LED_2: room: GLAN3
LANACT4 = LED_2: room: GLAN4
LANACT5 = LED_2: room: GLAN5
LANACT6 = LED_2: room: GLAN6
LANACT7 = LED_2: room: GLAN7
LANACT8 = LED_2: room: GLAN8
LANLINK1 = LED_0: room: GLAN1
LANLINK2 = LED_0: room: GLAN2
LANLINK3 = LED_0: room: GLAN3
LANLINK4 = LED_0: room: GLAN4
LANLINK5 = LED_0: room: GLAN5
LANLINK6 = LED_0: room: GLAN6
LANLINK7 = LED_0: room: GLAN7
LANLINK8 = LED_0: room: GLAN8
LED1 LED2 = LED_0: room: M2E
MCUCON1 = SIP\6P-M_0
MHB1 MHB2 = HOLE1_5: room: M2B
MHE1 = STAND OFF_0: room: M2E
MHM1 = STAND OFF_0: room: M2M
NCSI1 = HEADER 9_2: room: GLAN4
NGFF1 = MD2-LOTES-APC10105-P002A_1: room: M2B
NMEA0183 = HEADER 9_0: room: ISO422
NMEA2000 = HEADER 9_0: room: ISOCAN
OOB1 = HEADER 9_2: room: CVM
PL1 = CHOCK: room: 5VSB_S
PL2 = INDUCTOR IRON_0: room: 5VSB_S
PL3 = INDUCTOR IRON_0: room: 3V3SB_S
PL4 = INDUCTOR IRON_0: room: V12SB
PLED1 = LED,RED,0805_1: room: EEPROM
POE1 POE2 = HEADER 9_0: room: POE12
POE3 POE4 = HEADER 9_0: room: POE34
POE5 POE6 = HEADER 9_0: room: POE56
POE7 POE8 = HEADER 9_0: room: POE78
POESLT1 POESLT2 = HEADER_5: room: PWR_IN
PSON1-PSON3 = SW PUSHBUTTON_1: room: BUTTON
PWRBTN1 RECOVERY1 RESET1 = INVERTER CONNECTOR_1: room: BUTTON
Q2 = 2N7002DW: room: BTNMCU
Q3-Q5 = MOSFET N_14: room: BTNMCU
Q6-Q8 Q10 = 2N7002_2: room: MCU2
Q11-Q14 = 2N7002_2: room: DIO
Q15 = 2N3904_3: room: TPM-JTAG-BUZ
Q17 = MOSFET N_14: room: M2E
Q19 Q58 = MOSFET N_14: room: EEPROM
Q20-Q27 = MOSFET P_1: room: POEMFET
Q29 = MOSFET N_4: room: ASM_PWR
Q30 Q31 = MOSFET P_1: room: DCIN
Q32 Q34 = MOSFET N_14: room: DCIN
Q33 = 2N7002DW: room: DCIN
Q36 = MOSFET P_1: room: 5VSB_S
Q37 Q38 = MOSFET N_14: room: 5VSB_S
Q39 Q40 = MOSFET P_1: room: 3V3SB_S
Q41 Q42 = MOSFET N_14: room: 3V3SB_S
Q43 Q44 = MOSFET P_1: room: V12SB
Q45-Q48 = MOSFET P_1: room: POEPWR
Q50 Q57 Q59 = MOSFET N_14: room: CVM
Q51 = 2N7002DW: room: TPM-JTAG-BUZ
Q52-Q54 = 2N7002DW: room: M2E
Q55 = 2N7002_2: room: HDMI
Q63-Q65 Q67 Q68 = MOSFET P_1: room: VS
Q66 Q69 = 2N7002DW: room: V_SM
R2 R3 R22 R23 RZ35 RZ36 RZ38-RZ41 RZ46 RZ47 RZ187 RZ188 RZ190 = R-0402_0: room: CVM
R4-R11 R1474 R1490 RB24 RB25 = RESISTOR: room: CVM
R24 R763 RZ25 RZ29 RZ34 RZ43 RZ44 RZ171 = R-0402: room: CVM
R29 R36 R40 R43 R46 R48 R51 R1479 R1482 RB5-RB13 RB22 RB63 = R#1: tolerance: 5 %; signal model: nv_res; room: BTNMCU
R31 = R: tolerance: 5 %; signal model: nv_res; room: BTNMCU
R42 R1478 = R#1: tolerance: 1 %; signal model: nv_res; room: BTNMCU
R56-R58 R61-R65 R81 R85 R1491 R1498-R1500 R1505 RZ112 RZ119 RZ199 = R-0402_0: room: MCU2
R84 = R-0603_0: room: MCU2
R86 R87 = R_7: room: MCU2
R90 R91 = R-0603: room: DIO
R92 R93 R98 R100 R101 RB26-RB28 = R#1: tolerance: 5 %; signal model: nv_res; room: EEPROM
R112 R123 R124 = R#1: tolerance: 5 %; signal model: nv_res; room: AUDIO
R114 = R: tolerance: 5 %; signal model: nv_res; room: AUDIO
R139 = R-0603: room: TPM-JTAG-BUZ
R141-R145 = R#1: tolerance: 5 %; signal model: nv_res; room: TPM-JTAG-BUZ
R155-R159 R166-R168 RA3-RA10 = R-0402_4: room: USBHUB
R162-R165 RZ76 RZ82 RZ90 RZU34 = R-0402: room: USBHUB
R170 R171 RB58 = R-0603: room: USB31
R172 R174 R175 RB1 RB2 RB60 RB61 = R0402: room: USB2COM
R173 R176 RZ9 RZ10 = R-0603: room: USB2COM
R177 R1508 = R_7: room: USB2COM
R178 = R: room: USB2COM
R181 R1512 R1513 RB59 RZ103 RZ207 RZ208 RZU35 = R-0603: room: USB-C
R187 R190-R202 = R-0402_0: room: M2E
R188 R189 R204 R1483 RZ21 RZ22 RZ167 RZ169 RZ170 RZ172-RZ176 RZU10-RZU18 RZU40-RZU42 = R-0402: room: M2E
R210 R212 R213 R215 R216 R221 R222 R224-R228 RZ142-RZ144 RZ146 RZ153 RZ154 RZ160 RZ162 RZU37 RZU39 = R-0402_0: room: M2B
R223 RZ147 = R-0402: room: M2B
R230 = R: room: EEPROM
R240 = R: tolerance: 5 %; signal model: nv_res; room: EEPROM
R242 R243 R246 R247 R756 RB4 = R-0402: room: CAMERA
R245 = R_43: room: CAMERA
R249 R251 = R0603: room: ISO422
R253 R254 R257 R259 R1511 RB3 RB62 RZ145 RZ148 RZ688 = R-0402: room: ISO422
R260 = R_7: room: ISOCAN
R261 R262 = R: room: ISOCAN
R264 R267 = R-0603: room: ISOCAN
R265 RZU1 RZU2 = R-0402_0: room: ISOCAN
R269 R270 R275-R285 R287 R290 R291 RA16 RA23 RA30 RA31 RA33 RA66-RA68 RA76 RA83 RA89-RA92 RA129-RA132 RB14 = R-0402_4: room: GLAN1
R273 = 10K-1%-R2_1: room: GLAN1
R274 RZ117 RZ128 RZ135 = R-0402: room: GLAN1
R286 R288 R289 = R-0603: room: GLAN1
R293 R295 R299-R309 R311 R314 R315 RA20 RA25 RA34 RA40 RA46 RA74 RA81 RA88 RA98 RA104 RA115 RA116 RA127 RA128 RA153-RA156 RB15 = R-0402_4: room: GLAN2
R294 = 10K-1%-R2_1: room: GLAN2
R298 RZ122 RZ130 RZ137 = R-0402: room: GLAN2
R310 R312 R313 = R-0603: room: GLAN2
R317 R318 R323-R332 R334 R335 R338 R339 RA21 RA26 RA35 RA41 RA47 RA73 RA80 RA87 RA97 RA103 RA113 RA114 RA125 RA126 RA149-RA152 RB16 = R-0402_4: room: GLAN3
R321 = 10K-1%-R2_1: room: GLAN3
R322 RZ123 RZ131 RZ138 = R-0402: room: GLAN3
R333 R336 R337 = R-0603: room: GLAN3
R341 R343 R347-R355 R357-R359 R362 R363 RA18 RA27 RA36 RA42 RA48 RA72 RA79 RA86 RA96 RA102 RA111 RA112 RA123 RA124 RA145-RA148 RB17 = R-0402_4: room: GLAN4
R342 = 10K-1%-R2_1: room: GLAN4
R346 RZ124 RZ132 RZ139 = R-0402: room: GLAN4
R356 R360 R361 = R-0603: room: GLAN4
R364 R366 R371-R380 R382 R383 R386 R387 RA22 RA28 RA37 RA43 RA49 RA71 RA78 RA85 RA95 RA101 RA109 RA110 RA121 RA122 RA141-RA144 RB18 = R-0402_4: room: GLAN5
R369 = 10K-1%-R2_1: room: GLAN5
R370 RZ125 RZ133 RZ140 = R-0402: room: GLAN5
R381 R384 R385 = R-0603: room: GLAN5
R389 R390 R395-R404 R406 R407 R410 R411 RA19 RA29 RA38 RA44 RA50 RA70 RA77 RA84 RA94 RA100 RA107 RA108 RA119 RA120 RA137-RA140 RB19 = R-0402_4: room: GLAN6
R393 = 10K-1%-R2_1: room: GLAN6
R394 RZ126 RZ134 RZ141 = R-0402: room: GLAN6
R405 R408 R409 = R-0603: room: GLAN6
R412 R414 R419-R428 R430 R431 R434 R435 RA17 RA24 RA32 RA39 RA45 RA69 RA75 RA82 RA93 RA99 RA105 RA106 RA117 RA118 RA133-RA136 RB20 = R-0402_4: room: GLAN7
R417 = 10K-1%-R2_1: room: GLAN7
R418 RZ127 RZ129 RZ136 = R-0402: room: GLAN7
R429 R432 R433 = R-0603: room: GLAN7
R437 R438 R443-R453 R455 R458 R459 RA11-RA15 RA53-RA65 RB21 = R-0402_4: room: GLAN8
R441 = 10K-1%-R2_1: room: GLAN8
R442 RZ99 RZ104 RZ105 = R-0402: room: GLAN8
R454 R456 R457 = R-0603: room: GLAN8
R460-R467 = RES: room: POE12
R468-R475 = RES: room: POE34
R476-R483 = RES: room: POE56
R484-R491 = RES: room: POE78
R496-R503 = RL3720WT-R018-G: room: POEMFET
R504-R527 R529-R539 RZU28 RZU46 RZU47 = RESISTOR: room: HDMI
R528 = R: room: HDMI
R540 R541 RZU45 = R0402_0: room: HDMI
R558-R561 RZ179-RZ182 RZ193 RZ196 RZU21 = R-0402: room: ASM1812
R562 R563 R565-R571 R574 R575 R578 R579 R583 R585 R587 R589 R605-R608 R610 R615 R618 RZ33 RZ37 RZ42 RZ48 RZ50 RZ52 RZ54 RZ55 RZ59 RZ60 RZ65 RZ68 RZ183-RZ186 RZ195 RZ197 RZ198 RZU29 RZU43 RZU44 = R-0402_0: room: ASM1812
R621 R622 R625-R628 R632 R634 R635 RZ80 RZ81 RZ83-RZ85 RZ87 RZ88 RZ92-RZ94 RZ96 RZ97 RZ101 RZ102 RZ106 RZ107 = R0402: room: ASM1806
R629-R631 R633 R638 R641 RZ89 RZ108 = R-0402: room: ASM1806
R636 R637 R639 R640 R644 R645 R648 RZ109-RZ111 RZ114 RZU36 = R-0402_0: room: ASM1806
R651 R654 R655 R659 R661 = R-0402: room: ASM_PWR
R662 = R_11: room: DCIN
R663 R665 = R-0402_0: room: DCIN
R664 R667 R669 R673 R674 RZ3 RZ8 = R_7: room: DCIN
R668 = R-0603: room: DCIN
R670 R671 = R-0603_0: room: DCIN
R677 R680 R682 = R0603: room: BUTTON
R681 RB64 RB66 = R0402: room: BUTTON
R684-R692 RB43 RZ58 RZ113 RZ116 RZ189 RZ191 = R-0402: room: 5VSB_S
R693 R694 = R-0402_0: room: 5VSB_S
R695-R701 RZ45 RZ49 RZ53 RZ118 RZ121 = R-0402: room: 3V3SB_S
R702-R704 = R-0402_0: room: 3V3SB_S
R705 R711 R714 R715 RB32 RB34 RB35 RZ56 RZ57 = R-0402_0: room: 1V8SB_1V2SB
R706 R713 = R-0402: room: 1V8SB_1V2SB
R718-R727 RB23 = R_7: room: V12SB
R729 R730 = RL3720WT-R018-G: room: POEPWR
R731 R733 R735 R737-R742 R744 R746-R749 R751-R753 R1510 RB29 RB30 RZ24 RZ26 RZ27 RZ31 RZ177 RZ687 RZU19 = R_7: room: POEPWR
R757 R759-R761 RZ23 RZ178 RZU22 RZU23 = R-0402_0: room: M2M
R762 = R_7: room: AUDIO
R768 R769 R771 R1484-R1486 R1488 RB36-RB39 RB42 = R-0402: room: TPM-JTAG-BUZ
R1334 = R-0603: room: EEPROM
R1475 R1476 RB56 RB57 RZ86 RZ91 RZ115 RZ120 RZ205 RZ206 RZU9 = R-0402_0: room: EEPROM
R1477 = R-0402: room: DIO
R1493 = R0402_0: room: AUDIO
R1506 R1507 = R-0402: room: VS
R1509 = R0201_3: room: EEPROM
RA1 RA2 = R-0402_4: room: 1V8SB_1V2SB
RA51 = R-0402_4: room: M2B
RA52 = R-0402_4: room: M2E
RB31 RB33 RB40 RB41 = R-0402_0: room: ASM_PWR
RB44-RB46 RB65 = R_7: room: POECTL
RB47-RB55 RZ67 RZU31 = R0402: room: DIO
RZ1 = R0402: room: TPM-JTAG-BUZ
RZ2 = R-0402_0: room: CAMERA
RZ4-RZ6 RZ28 RZ30 RZ32 RZU3-RZU5 = R: tolerance: 0.05 ohm; signal model: nv_res; room: BTNMCU
RZ7 RZ12 RZ157 RZ158 RZ164 RZ166 RZ168 = R: tolerance: 0.05 ohm; signal model: ?; room: AUDIO
RZ11 RZ19 RZ149-RZ152 RZU6 = R-0402_0: room: BUTTON
RZ13 = R#1: tolerance: 0.05 ohm; signal model: nv_res; room: CVM
RZ14-RZ18 = R: tolerance: 0.05 ohm; signal model: nv_res; room: CVM
RZ20 RZU8 = R: tolerance: 0.05 ohm; signal model: nv_res; room: EEPROM
RZ51 RZU26 = R_7: room: 1V8SB_1V2SB
RZ61 RZ192 = RES: room: TPM-JTAG-BUZ
RZ62-RZ64 = RES: room: POECTL
RZ66 RZ69-RZ71 RZ75 RZ77 RZ200 RZ202 = RES: room: POEMFET
RZ72 RZ73 RZ78 RZU30 = R-0402_0: room: DIO
RZ74 RZ95 = R0402_0: room: USBHUB
RZ79 RZ98 = R-0402_0: room: USBHUB
RZ100 = R-0402_0: room: USB31
RZ155 RZ156 RZ159 RZ161 RZ163 RZ165 = R: tolerance: 0.05 ohm; signal model: nv_res; room: AUDIO
RZ194 = R0402: room: ASM_PWR
RZ201 RZ203 RZ204 = R0402: room: MCU2
RZ685 RZ686 = R-0402_0: room: AUDIO
RZU7 = R: tolerance: 0.05 ohm; signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: CVM
RZU20 RZU24 RZU38 = R#1: tolerance: 0.05 ohm; signal model: nv_res; room: BTNMCU
RZU25 RZU27 = R_7: room: ASM_PWR
RZU32 RZU33 = RES: room: ASM1806
S2-S5 = R_0: room: ASM1812
S6 = R_0: room: 5VSB_S
S8 = R0603_5: room: M2M
SPI1 = IC_EEPROM-SPI: room: ASM1812
SPI2 = IC_EEPROM-SPI: room: ASM1806
SSD2 = NGFF_KEY_B_0: room: M2M
SW1 SW2 = SW PUSHBUTTON_0: room: MCU2
TH1-TH4 = 1N5817_3: room: POE78
TP1-TP5 = LABTESTPOINT#1: room: CVM
TP6-TP10 TP60 = LABTESTPOINT: room: CVM
TP11 = TEST_POINT_0: room: CVM
TP12-TP17 TP56-TP59 = LABTESTPOINT: room: BTNMCU
TP18 = SD CARD_1: room: MCU2
TP19 TP21 = LABTESTPOINT: room: EEPROM
TP20 TP22 TP23 = LABTESTPOINT#1: room: EEPROM
TP24-TP27 = LABTESTPOINT#1: room: AUDIO
TP28 TP29 = LABTESTPOINT: room: AUDIO
TP30-TP34 = LABTESTPOINT: room: TPM-JTAG-BUZ
TP35-TP38 = MISC_TESTPOINT: room: USB2COM
TP39 = TP_0: room: M2E
TP40-TP45 = 620NOPN008_0: room: M2B
TP47 TP48 = TP_0: room: ASM1812
TP49 = TP_0: room: ASM1806
TP50 = LABTESTPOINT: room: 5VSB_S
TP51 = LABTESTPOINT: room: 3V3SB_S
TP52-TP55 = LABTESTPOINT#1: room: CAMERA
U3-U5 = NC7SZ08_1: room: CVM
U6 = U_CPU_EFM8SB1: room: BTNMCU
U7 = U_LEVSHFT_3STATE: room: BTNMCU
U9 U12 U91 = TSSOP-NEXPERIA-74AUP1G32GW: room: BTNMCU
U10 = TSSOP-NXP-74AUP1G07GW_1: room: BTNMCU
U11 = TSSOP-NXP-74AHC1G08GW: room: BTNMCU
U13 = LPC54000_16: room: MCU2
U14 = F75111R_0: room: DIO_TPM
U15 = 24C02: room: EEPROM
U16 = U_ACODEC_ALC5640_0: room: AUDIO
U18 = CT379_DP2VGA+CVBS_6: room: TPM-JTAG-BUZ
U19 = NC7SZ08_1: room: TPM-JTAG-BUZ
U20 = GL3520_QFN88_V094-1_0: room: USBHUB
U21 = IC_EEPROM-SPI: room: USBHUB
U22 U23 = MIC2009: room: USB31
U24 U26 = MX211_1: room: USB2COM
U25 = F81534_3: room: USB2COM
U27 = 24C02_33: room: USB2COM
U29 = OSC_4PIN: room: M2E
U30 = ALP5331_1: room: M2E
U32 = ALP5331_1: room: M2B
U33 = U_BUF_3_STATE: room: EEPROM
U34 = SC454_MLP_22: room: CAMERA
U36 U38 = MX211_1: room: ISO422
U39 = 24C02_33: room: ISOCAN
U40 = MX211_2: room: ISOCAN
U41 = I210-AT_4: room: GLAN1
U42 = SPI EEPROM_1: room: GLAN1
U43 = I210-AT_4: room: GLAN2
U44 = SPI EEPROM_1: room: GLAN2
U45 = I210-AT_4: room: GLAN3
U46 = SPI EEPROM_1: room: GLAN3
U47 = I210-AT_4: room: GLAN4
U48 = SPI EEPROM_1: room: GLAN4
U49 = I210-AT_4: room: GLAN5
U50 = SPI EEPROM_1: room: GLAN5
U51 = I210-AT_4: room: GLAN6
U52 = SPI EEPROM_1: room: GLAN6
U53 = I210-AT_4: room: GLAN7
U54 = SPI EEPROM_1: room: GLAN7
U55 = I210-AT_4: room: GLAN8
U56 = SPI EEPROM_1: room: GLAN8
U57 U58 = LF9209A_0: room: POE12
U59 U60 = LF9209A_0: room: POE34
U61 U62 = LF9209A_0: room: POE56
U63 U64 = LF9209A_0: room: POE78
U65 = 10179_1: room: POECTL
U66 = RTL8111G_3: room: HDMI
U67 = ASM2824
U70 = AR9281_AL1A_0
U72 U73 = SC454_MLP_2: room: ASM_PWR
U74 = ALP5331_4: room: DCIN
U75 = MIC811SUTR_0: room: DCIN
U76 = BIT3109P_0: room: 5VSB_S
U77 = BIT3109P_2: room: 3V3SB_S
U78 U79 = SC454_MLP_2: room: 1V8SB_1V2SB
U80 U81 = ALP5331_1: room: 1V8SB_1V2SB
U83 = 10179_1: room: POEPWR
U84 = OSC_4PIN: room: M2M
U85 = EN25F80_2: room: CVM
U86 = F75111R_3: room: TPM-JTAG-BUZ
U87 = 24C02_3: room: EEPROM
U88 U89 = 2280005000G_1: room: CVM
U90 = 2280005000G_1: room: BTNMCU
U92 = USB_FUSB302B_1: room: V12SB
UART1 = HEADER 9_2: room: USB2COM
UNK@U28 = MIC2009: room: USB-C
USB1 = W_0: room: USB-C
VS1-VS5 = VIRTUAL_SHORT: room: AUDIO
WIFI1 = NGFF_KEY_B_1: room: M2E
X1 = XTAL_CYLIN_3: room: USBHUB
X2 = XTAL_CYLIN_3: room: GLAN1
X3 = XTAL_CYLIN_3: room: GLAN2
X4 = XTAL_CYLIN_3: room: GLAN3
X5 = XTAL_CYLIN_3: room: GLAN4
X6 = XTAL_CYLIN_3: room: GLAN5
X7 = XTAL_CYLIN_3: room: GLAN6
X8 = XTAL_CYLIN_3: room: GLAN7
X9 = XTAL_CYLIN_3: room: GLAN8
X10 = XTAL_CYLIN_3: room: ASM1812
X11 = XTAL_CYLIN_3: room: ASM1806
Y1 = XTAL_CYLIN_3: room: USB2COM
Y2 = CRYSTAL_4P: room: HDMI
Z1-Z6 = V-PORT-220-V05_0: room: MCU2
Z7 Z9 Z12 = V-PORT-220-V05_0: room: BUTTON
Z8 Z10 Z16-Z18 = V-PORT-220-V05_0: room: EEPROM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
ATX6P-WP
  round 2.997 hole 2.997 unplated: (-8.9,2.27) (8.9,2.27)
  rect 2.159x2.159 hole 1.397: 1(4.2,-2.75)
  round 2.159 hole 1.397: 2(0,-2.75) 3(-4.2,-2.75) 4(4.2,2.75) 5(0,2.75) 6(-4.2,2.75)
BGA492_21X21P08H15
  round 0.406 smd: A1(-10,10) A2(-9.2,10) A3(-8.4,10) A4(-7.6,10) A5(-6.8,10) A6(-6,10) A7(-5.2,10) A8(-4.4,10) A9(-3.6,10) A10(-2.8,10) A11(-2,10) A12(-1.2,10) A13(-0.4,10) A14(0.4,10) A15(1.2,10) A16(2,10) A17(2.8,10) A18(3.6,10) A19(4.4,10) A20(5.2,10) A21(6,10) A22(6.8,10) A23(7.6,10) A24(8.4,10) A25(9.2,10) A26(10,10) AA1(-10,-6) AA2(-9.2,-6) AA3(-8.4,-6) AA4(-7.6,-6) AA5(-6.8,-6) AA6(-6,-6) AA7(-5.2,-6) AA8(-4.4,-6) AA9(-3.6,-6) AA12(-1.2,-6) AA13(-0.4,-6) AA14(0.4,-6) AA15(1.2,-6) AA16(2,-6) AA24(8.4,-6) AA25(9.2,-6) AA26(10,-6) AB1(-10,-6.8) AB2(-9.2,-6.8) AB3(-8.4,-6.8) AB4(-7.6,-6.8) AB5(-6.8,-6.8) AB6(-6,-6.8) AB7(-5.2,-6.8) AB8(-4.4,-6.8) AB9(-3.6,-6.8) AB10(-2.8,-6.8) AB11(-2,-6.8) AB12(-1.2,-6.8) AB13(-0.4,-6.8) AB14(0.4,-6.8) AB17(2.8,-6.8) AB18(3.6,-6.8) AB21(6,-6.8) AB22(6.8,-6.8) AB23(7.6,-6.8) AB24(8.4,-6.8) AB25(9.2,-6.8) AB26(10,-6.8) AC1(-10,-7.6) AC2(-9.2,-7.6) AC3(-8.4,-7.6) AC4(-7.6,-7.6) AC5(-6.8,-7.6) AC6(-6,-7.6) AC7(-5.2,-7.6) AC8(-4.4,-7.6) AC9(-3.6,-7.6) AC10(-2.8,-7.6) AC11(-2,-7.6) AC12(-1.2,-7.6) AC13(-0.4,-7.6) AC14(0.4,-7.6) AC15(1.2,-7.6) AC16(2,-7.6) AC17(2.8,-7.6) AC18(3.6,-7.6) AC19(4.4,-7.6) AC20(5.2,-7.6) AC21(6,-7.6) AC22(6.8,-7.6) AC23(7.6,-7.6) AC24(8.4,-7.6) AC25(9.2,-7.6) AC26(10,-7.6) AD1(-10,-8.4) AD2(-9.2,-8.4) AD3(-8.4,-8.4) AD4(-7.6,-8.4) AD5(-6.8,-8.4) AD6(-6,-8.4) AD7(-5.2,-8.4) AD8(-4.4,-8.4) AD9(-3.6,-8.4) AD10(-2.8,-8.4) AD11(-2,-8.4) AD12(-1.2,-8.4) AD13(-0.4,-8.4) AD14(0.4,-8.4) AD15(1.2,-8.4) AD16(2,-8.4) AD17(2.8,-8.4) AD18(3.6,-8.4) AD19(4.4,-8.4) AD20(5.2,-8.4) AD21(6,-8.4) AD22(6.8,-8.4) AD23(7.6,-8.4) AD24(8.4,-8.4) AD25(9.2,-8.4) AD26(10,-8.4) AE1(-10,-9.2) AE2(-9.2,-9.2) AE3(-8.4,-9.2) AE4(-7.6,-9.2) AE5(-6.8,-9.2) AE6(-6,-9.2) AE7(-5.2,-9.2) AE8(-4.4,-9.2) AE9(-3.6,-9.2) AE10(-2.8,-9.2) AE11(-2,-9.2) AE12(-1.2,-9.2) AE13(-0.4,-9.2) AE14(0.4,-9.2) AE15(1.2,-9.2) AE16(2,-9.2) AE17(2.8,-9.2) AE18(3.6,-9.2) AE19(4.4,-9.2) AE20(5.2,-9.2) AE21(6,-9.2) AE22(6.8,-9.2) AE23(7.6,-9.2) AE24(8.4,-9.2) AE25(9.2,-9.2) AE26(10,-9.2) AF1(-10,-10) AF2(-9.2,-10) AF3(-8.4,-10) AF4(-7.6,-10) AF5(-6.8,-10) AF6(-6,-10) AF7(-5.2,-10) AF8(-4.4,-10) AF9(-3.6,-10) AF10(-2.8,-10) AF11(-2,-10) AF12(-1.2,-10) AF13(-0.4,-10) AF14(0.4,-10) AF15(1.2,-10) AF16(2,-10) AF17(2.8,-10) AF18(3.6,-10) AF19(4.4,-10) AF20(5.2,-10) AF21(6,-10) AF22(6.8,-10) AF23(7.6,-10) AF24(8.4,-10) AF25(9.2,-10) AF26(10,-10) B1(-10,9.2) B2(-9.2,9.2) B3(-8.4,9.2) B4(-7.6,9.2) B5(-6.8,9.2) B6(-6,9.2) B7(-5.2,9.2) B8(-4.4,9.2) B9(-3.6,9.2) B10(-2.8,9.2) B11(-2,9.2) B12(-1.2,9.2) B13(-0.4,9.2) B14(0.4,9.2) B15(1.2,9.2) B16(2,9.2) B17(2.8,9.2) B18(3.6,9.2) B19(4.4,9.2) B20(5.2,9.2) B21(6,9.2) B22(6.8,9.2) B23(7.6,9.2) B24(8.4,9.2) B25(9.2,9.2) B26(10,9.2) C1(-10,8.4) C2(-9.2,8.4) C3(-8.4,8.4) C4(-7.6,8.4) C5(-6.8,8.4) C6(-6,8.4) C7(-5.2,8.4) C8(-4.4,8.4) C9(-3.6,8.4) C10(-2.8,8.4) C11(-2,8.4) C12(-1.2,8.4) C13(-0.4,8.4) C14(0.4,8.4) C15(1.2,8.4) C16(2,8.4) C17(2.8,8.4) C18(3.6,8.4) C19(4.4,8.4) C20(5.2,8.4) C21(6,8.4) C22(6.8,8.4) C23(7.6,8.4) C24(8.4,8.4) C25(9.2,8.4) C26(10,8.4) D1(-10,7.6) D2(-9.2,7.6) D3(-8.4,7.6) D4(-7.6,7.6) D5(-6.8,7.6) D6(-6,7.6) D7(-5.2,7.6) D8(-4.4,7.6) D9(-3.6,7.6) D10(-2.8,7.6) D11(-2,7.6) D12(-1.2,7.6) D13(-0.4,7.6) D14(0.4,7.6) D15(1.2,7.6) D16(2,7.6) D17(2.8,7.6) D18(3.6,7.6) D19(4.4,7.6) D20(5.2,7.6) D21(6,7.6) D22(6.8,7.6) D23(7.6,7.6) D24(8.4,7.6) D25(9.2,7.6) D26(10,7.6) E1(-10,6.8) E2(-9.2,6.8) E3(-8.4,6.8) E4(-7.6,6.8) E5(-6.8,6.8) E6(-6,6.8) E7(-5.2,6.8) E8(-4.4,6.8) E9(-3.6,6.8) E10(-2.8,6.8) E11(-2,6.8) E12(-1.2,6.8) E13(-0.4,6.8) E14(0.4,6.8) E16(2,6.8) E17(2.8,6.8) E18(3.6,6.8) E19(4.4,6.8) E23(7.6,6.8) E24(8.4,6.8) E25(9.2,6.8) E26(10,6.8) F1(-10,6) F2(-9.2,6) F3(-8.4,6) F4(-7.6,6) F5(-6.8,6) F6(-6,6) F7(-5.2,6) F8(-4.4,6) F19(4.4,6) F23(7.6,6) F24(8.4,6) F25(9.2,6) F26(10,6) G1(-10,5.2) G2(-9.2,5.2) G3(-8.4,5.2) G4(-7.6,5.2) G5(-6.8,5.2) G23(7.6,5.2) G24(8.4,5.2) G25(9.2,5.2) G26(10,5.2) H1(-10,4.4) H2(-9.2,4.4) H3(-8.4,4.4) H4(-7.6,4.4) H23(7.6,4.4) H24(8.4,4.4) H25(9.2,4.4) H26(10,4.4) J1(-10,3.6) J2(-9.2,3.6) J3(-8.4,3.6) J4(-7.6,3.6) J8(-4.4,3.6) J9(-3.6,3.6) J10(-2.8,3.6) J11(-2,3.6) J14(0.4,3.6) J15(1.2,3.6) J16(2,3.6) J17(2.8,3.6) J18(3.6,3.6) J23(7.6,3.6) J24(8.4,3.6) J25(9.2,3.6) J26(10,3.6) K1(-10,2.8) K2(-9.2,2.8) K3(-8.4,2.8) K4(-7.6,2.8) K8(-4.4,2.8) K9(-3.6,2.8) K10(-2.8,2.8) K11(-2,2.8) K12(-1.2,2.8) K13(-0.4,2.8) K14(0.4,2.8) K15(1.2,2.8) K16(2,2.8) K17(2.8,2.8) K18(3.6,2.8) K23(7.6,2.8) K24(8.4,2.8) K25(9.2,2.8) K26(10,2.8) L1(-10,2) L2(-9.2,2) L3(-8.4,2) L4(-7.6,2) L8(-4.4,2) L9(-3.6,2) L10(-2.8,2) L11(-2,2) L12(-1.2,2) L13(-0.4,2) L14(0.4,2) L15(1.2,2) L16(2,2) L17(2.8,2) L18(3.6,2) L23(7.6,2) L24(8.4,2) L25(9.2,2) L26(10,2) M1(-10,1.2) M2(-9.2,1.2) M3(-8.4,1.2) M4(-7.6,1.2) M8(-4.4,1.2) M9(-3.6,1.2) M10(-2.8,1.2) M11(-2,1.2) M12(-1.2,1.2) M13(-0.4,1.2) M14(0.4,1.2) M15(1.2,1.2) M16(2,1.2) M17(2.8,1.2) M18(3.6,1.2) M23(7.6,1.2) M24(8.4,1.2) M25(9.2,1.2) M26(10,1.2) N1(-10,0.4) N2(-9.2,0.4) N3(-8.4,0.4) N4(-7.6,0.4) N8(-4.4,0.4) N9(-3.6,0.4) N10(-2.8,0.4) N11(-2,0.4) N12(-1.2,0.4) N13(-0.4,0.4) N14(0.4,0.4) N15(1.2,0.4) N16(2,0.4) N17(2.8,0.4) N18(3.6,0.4) N23(7.6,0.4) N24(8.4,0.4) N25(9.2,0.4) N26(10,0.4) P1(-10,-0.4) P2(-9.2,-0.4) P3(-8.4,-0.4) P4(-7.6,-0.4) P8(-4.4,-0.4) P9(-3.6,-0.4) P10(-2.8,-0.4) P11(-2,-0.4) P12(-1.2,-0.4) P13(-0.4,-0.4) P14(0.4,-0.4) P15(1.2,-0.4) P16(2,-0.4) P17(2.8,-0.4) P18(3.6,-0.4) P23(7.6,-0.4) P24(8.4,-0.4) P25(9.2,-0.4) P26(10,-0.4) R1(-10,-1.2) R2(-9.2,-1.2) R3(-8.4,-1.2) R4(-7.6,-1.2) R8(-4.4,-1.2) R9(-3.6,-1.2) R10(-2.8,-1.2) R11(-2,-1.2) R12(-1.2,-1.2) R13(-0.4,-1.2) R14(0.4,-1.2) R15(1.2,-1.2) R16(2,-1.2) R17(2.8,-1.2) R18(3.6,-1.2) R23(7.6,-1.2) R24(8.4,-1.2) R25(9.2,-1.2) R26(10,-1.2) T1(-10,-2) T2(-9.2,-2) T3(-8.4,-2) T4(-7.6,-2) T8(-4.4,-2) T9(-3.6,-2) T10(-2.8,-2) T11(-2,-2) T12(-1.2,-2) T13(-0.4,-2) T14(0.4,-2) T15(1.2,-2) T16(2,-2) T17(2.8,-2) T18(3.6,-2) T23(7.6,-2) T24(8.4,-2) T25(9.2,-2) T26(10,-2) U1(-10,-2.8) U2(-9.2,-2.8) U3(-8.4,-2.8) U4(-7.6,-2.8) U8(-4.4,-2.8) U9(-3.6,-2.8) U10(-2.8,-2.8) U13(-0.4,-2.8) U14(0.4,-2.8) U15(1.2,-2.8) U16(2,-2.8) U17(2.8,-2.8) U18(3.6,-2.8) U23(7.6,-2.8) U24(8.4,-2.8) U25(9.2,-2.8) U26(10,-2.8) V1(-10,-3.6) V2(-9.2,-3.6) V3(-8.4,-3.6) V4(-7.6,-3.6) V23(7.6,-3.6) V24(8.4,-3.6) V25(9.2,-3.6) V26(10,-3.6) W1(-10,-4.4) W2(-9.2,-4.4) W3(-8.4,-4.4) W4(-7.6,-4.4) W22(6.8,-4.4) W23(7.6,-4.4) W24(8.4,-4.4) W25(9.2,-4.4) W26(10,-4.4) Y1(-10,-5.2) Y2(-9.2,-5.2) Y3(-8.4,-5.2) Y4(-7.6,-5.2) Y22(6.8,-5.2) Y23(7.6,-5.2) Y24(8.4,-5.2) Y25(9.2,-5.2) Y26(10,-5.2)
