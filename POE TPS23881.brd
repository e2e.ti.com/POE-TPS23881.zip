# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_DWN_DM4: length 147.6
  TOP w0.102: v1(59.33,145.27) 59.56,145.5 59.56,146.18 61.21,147.83 81.92,147.83 82.12,148.03 82.12,148.16 RZ9.2 ; v1(81.38,60.84) 81.15,61.06 81.15,61.74 81.22,61.82 U20.64
  IN3 w0.109: v1(59.33,145.27) 59.56,145.5 59.56,145.69 59.45,145.8 58.7,145.8 57.8,144.89 57.8,144.69 57.57,144.46 57.37,144.46 57.14,144.23 57.14,144.03 56.9,143.79 56.7,143.79 56.47,143.56 56.47,143.36 56.24,143.13 56.04,143.13 48.9,135.99 48.9,133.91 49.04,133.77 49.04,133.44 48.9,133.3 48.9,132.97 49.04,132.83 49.04,132.5 48.9,132.36 48.9,118.36 50.09,117.17 50.29,117.17 50.52,116.94 50.52,116.74 50.75,116.51 50.95,116.51 51.19,116.27 51.19,116.07 53.24,114.02 53.24,109.47 54.94,107.77 68.83,107.77 69.13,108.08 73.2,108.08 75.97,105.31 75.97,94.62 76.73,93.86 76.73,82.55 76.4,82.22 76.4,75.92 74.88,74.39 74.88,73.63 74.12,72.87 74.12,63.05 75.62,61.54 80.89,61.54 81.15,61.29 81.15,61.06 v1(81.38,60.84)
USB2_DWN_DP1: length 45.8
  TOP w0.102: L2.4 108.22,54.26 107.95,54.53 107.29,54.53 106.12,55.7 91.97,55.7 90.25,57.43 90.25,57.94 v1(90.02,58.17) ; U20.22 85.22,71.32 85.15,71.39 85.15,71.67 85.44,71.96 85.44,72.1 v1(85.69,72.34)
  IN3 w0.109: v1(85.69,72.34) 85.46,72.57 85.46,73.3 85.69,73.53 86.46,73.53 86.6,73.39 86.93,73.39 87.07,73.53 87.4,73.53 87.54,73.39 87.87,73.39 88.01,73.53 88.34,73.53 88.48,73.39 88.81,73.39 88.95,73.53 89.92,73.53 92.48,70.97 92.48,70.41 92.34,70.27 92.34,69.94 92.48,69.8 92.48,69.47 92.34,69.33 92.34,69 92.48,68.86 92.48,63.88 91.91,63.31 91.71,63.31 91.48,63.08 91.48,62.88 91.24,62.65 91.04,62.65 90.81,62.42 90.81,62.21 90.25,61.65 90.25,58.39 v1(90.02,58.17)
USB2_DWN_DP2: length 27.8
  TOP w0.102: U20.75 85.62,61.8 85.7,61.73 85.7,60.43 91.19,54.94 105.23,54.94 107.57,52.6 107.9,52.6 108.15,52.36 L1.4
USB2_DWN_DP3: length 84.8
  TOP w0.102: U13.5 142.77,68.3 142.65,68.42 139.37,68.42 v1(139.14,68.19) ; U20.60 79.62,61.88 79.7,61.81 79.7,61.66 79.55,61.52 79.2,61.52 78.95,61.27 78.95,61.05 v1(78.71,60.81)
  IN1 w0.109: v1(139.14,68.19) 139.37,68.42 139.63,68.42 140.03,68.82 140.03,69.73 137.37,72.39 133.65,72.39 133.23,71.97 116.96,71.97 113.36,75.56 106.22,75.56 105.31,74.65 105.31,70.34 104.24,69.27 97.74,69.27 96.75,68.28 96.75,64.62 96.39,64.26 93.65,64.26 92.83,63.45 90.88,63.45 89.99,62.56 87,62.56 86.34,63.22 79.5,63.22 78.94,62.67 78.94,61.04 v1(78.71,60.81)
USB2_DWN_DP4: length 147.6
  TOP w0.102: U20.63 80.82,61.77 80.9,61.7 80.9,61.06 v1(80.67,60.84) ; v1(60.05,145.27) 59.82,145.5 59.82,146.07 61.32,147.57 82.02,147.57 82.37,147.93 82.37,148.18 RZ10.2
  IN3 w0.109: v1(80.67,60.84) 80.9,61.06 80.9,61.18 80.79,61.29 75.51,61.29 73.86,62.94 73.86,72.97 74.63,73.74 74.63,74.5 76.15,76.02 76.15,82.33 76.48,82.66 76.48,93.75 75.72,94.51 75.72,105.2 73.1,107.82 69.24,107.82 68.94,107.52 54.83,107.52 52.98,109.37 52.98,113.92 48.64,118.26 48.64,136.09 58.6,146.05 59.56,146.05 59.82,145.79 59.82,145.5 v1(60.05,145.27)
USB3_DWN_RXN1: length 29
  TOP w0.102: v1(98.61,68.05) 98.83,67.82 100.76,67.82 101.03,68.09 L4.1 ; v1(83.67,74.58) 83.44,74.35 83.44,74.06 83.16,73.78 83.16,71.35 83.22,71.29 U20.27
  BOTTOM w0.102: v1(98.61,68.05) 98.83,67.82 98.93,67.82 99.03,67.92 99.03,68.4 98.65,68.78 98.44,68.78 98.22,69 98.22,69.21 98.01,69.43 97.79,69.43 97.58,69.64 97.58,69.85 97.36,70.07 97.15,70.07 96.94,70.29 96.94,70.5 94.33,73.1 93.75,73.1 93.6,72.95 93.29,72.95 93.14,73.1 92.84,73.1 92.69,72.95 92.38,72.95 92.24,73.1 91.92,73.1 91.77,72.95 91.47,72.95 91.32,73.1 90.68,73.1 89.59,74.19 89.38,74.19 89.16,74.41 89.16,74.62 88.95,74.83 88.73,74.83 88.52,75.05 88.52,75.26 87.83,75.95 87.07,75.95 86.92,75.8 86.61,75.8 86.46,75.95 86.16,75.95 86.01,75.8 85.7,75.8 85.55,75.95 83.82,75.95 83.44,75.56 83.44,74.81 v1(83.67,74.58)
USB3_DWN_RXN2: length 11.4
  TOP w0.102: v1(85.32,58.81) 85.55,59.04 85.55,59.46 84.89,60.11 84.89,61.73 84.82,61.81 U20.73 ; L3.4 80.63,55.89 80.9,56.16 80.9,56.44 v1(80.67,56.67)
  IN3 w0.109: v1(80.67,56.67) 80.9,56.9 80.9,57.16 81.45,57.71 85.24,57.71 85.55,58.02 85.55,58.58 v1(85.32,58.81)
USB3_DWN_RXP1: length 29.1
  TOP w0.102: v1(82.96,74.58) 83.19,74.35 83.19,74.17 82.91,73.89 82.91,71.37 82.82,71.29 U20.28 ; L4.4 101.06,67.29 100.79,67.56 98.83,67.56 v1(98.61,67.34)
  BOTTOM w0.102: v1(98.61,67.34) 98.83,67.56 99.04,67.56 99.29,67.81 99.29,68.5 94.44,73.36 90.78,73.36 87.94,76.2 83.71,76.2 83.19,75.67 83.19,74.81 v1(82.96,74.58)
USB3_DWN_RXP2: length 11.4
  TOP w0.102: v1(81.38,56.67) 81.15,56.44 81.15,56.16 81.43,55.89 L3.1 ; v1(86.03,58.81) 85.8,59.04 85.8,59.56 85.15,60.22 85.15,61.73 85.22,61.81 U20.74
  IN3 w0.109: v1(86.03,58.81) 85.8,58.58 85.8,57.91 85.34,57.45 81.55,57.45 81.15,57.05 81.15,56.9 v1(81.38,56.67)
USB3_DWN_TXN1: length 24.6
  TOP w0.102: U20.24 84.42,71.28 84.35,71.35 84.35,73.25 85.05,73.96 85.05,74.54 v1(85.28,74.77) ; CA74.1 98.46,65.53 98.25,65.53 v1(98.02,65.76)
  BOTTOM w0.102: v1(98.02,65.76) 97.79,65.53 97.39,65.53 97.28,65.64 97.28,68.63 94.26,71.65 90.02,71.65 88.88,72.79 88.88,73 88.66,73.22 88.45,73.22 88.24,73.43 88.24,73.65 88.02,73.86 87.81,73.86 87.43,74.24 86.41,74.24 86.26,74.39 85.95,74.39 85.8,74.24 85.21,74.24 85.05,74.4 85.05,74.54 v1(85.28,74.77)
USB3_DWN_TXN2: length 4.5
  TOP w0.102: CA79.1 83.19,58.46 83.19,58.71 83.7,59.21 83.7,61.69 83.62,61.77 U20.70
USB3_DWN_TXP1: length 24.7
  TOP w0.102: v1(84.57,74.77) 84.8,74.54 84.8,74.06 84.1,73.36 84.1,71.37 84.02,71.3 U20.25 ; CA75.1 98.46,65.28 98.25,65.28 v1(98.02,65.05)
  BOTTOM w0.102: v1(98.02,65.05) 97.79,65.28 97.28,65.28 97.03,65.53 97.03,68.53 94.15,71.4 89.91,71.4 87.32,73.99 85.1,73.99 84.8,74.29 84.8,74.54 v1(84.57,74.77)
USB3_DWN_TXP2: length 4.5
  TOP w0.102: CA78.1 83.44,58.46 83.44,58.6 83.95,59.11 83.95,61.7 84.02,61.77 U20.71
USB3_RXN1_CON: length 10.6
  TOP w0.102: CN1.5 111.53,69.84 111.43,69.74 110.98,69.74 110.26,69.01 108.66,69.01 107.07,67.43 106.01,67.43 105.88,67.55 D7.10 D7.1 104.5,67.55 104.39,67.44 104.32,67.44 103.94,67.82 103.53,67.82 103.26,68.09 L4.2
USB3_RXN2_CON: length 8.9
  TOP w0.102: CN2.5 79.12,47.18 79.22,47.28 79.22,47.78 81.08,49.64 81.08,50.63 81.36,50.91 81.36,51.13 81.25,51.24 D8.1 D8.10 81.25,52.53 81.37,52.65 81.37,52.76 80.9,53.23 80.9,53.47 80.63,53.74 L3.3
USB3_RXP1_CON: length 10.6
  TOP w0.102: L4.3 103.28,67.29 103.56,67.56 103.83,67.56 104.21,67.18 104.39,67.18 104.53,67.05 D7.2 D7.9 105.91,67.05 106.03,67.17 107.18,67.17 108.76,68.76 110.36,68.76 111.09,69.48 111.43,69.48 111.53,69.38 CN1.6
USB3_RXP2_CON: length 8.9
  TOP w0.102: L3.2 81.43,53.74 81.15,53.47 81.15,53.34 81.62,52.87 81.62,52.64 81.75,52.52 D8.9 D8.2 81.75,51.27 81.61,51.13 81.61,50.8 81.33,50.52 81.33,49.53 79.47,47.67 79.47,47.28 79.58,47.18 CN2.6
USB3_TXN1_CON: length 10.6
  TOP w0.102: CN1.8 111.53,63.84 111.43,63.74 111.24,63.74 110.41,64.57 108.61,64.57 107.25,65.92 106.03,65.92 105.91,66.05 D7.7 D7.4 104.55,66.05 104.44,65.94 104.17,65.94 103.76,65.53 103.56,65.53 103.28,65.81 L6.2
USB3_TXN2_CON: length 8.9
  TOP w0.102: L5.3 82.91,53.71 83.19,53.44 83.19,53.23 82.85,52.9 82.85,52.68 82.75,52.57 D8.7 D8.4 82.75,51.26 82.87,51.14 82.87,50.71 85.22,48.35 85.22,47.28 85.12,47.18 CN2.8
USB3_TXP1_CON: length 10.6
  TOP w0.102: CN1.9 111.53,63.38 111.43,63.48 111.14,63.48 110.31,64.31 108.5,64.31 107.15,65.67 106.01,65.67 105.88,65.55 D7.6 D7.5 104.56,65.55 104.42,65.68 104.28,65.68 103.87,65.28 103.58,65.28 103.31,65 L6.3
USB3_TXP2_CON: length 8.9
  TOP w0.102: CN2.9 85.58,47.18 85.47,47.28 85.47,48.46 83.12,50.81 83.12,51.13 83.25,51.25 D8.5 D8.6 83.25,52.52 83.11,52.65 83.11,52.8 83.44,53.13 83.44,53.44 83.71,53.71 L5.2
USB31_RX_DN: length 2.4
  BOTTOM w0.102: NGFF1.29 155.75,182.67 155.87,182.79 156.17,182.79 156.41,182.55 156.9,182.55 157,182.45 RZ143.2
USB31_RX_DP: length 2.4
  BOTTOM w0.102: RZ142.2 157,182.91 156.9,182.8 156.52,182.8 156.28,183.05 155.89,183.05 155.77,183.17 NGFF1.31
USB31_TX_DN: length 2.1
  BOTTOM w0.102: CA246.2 156.94,184.29 155.96,184.29 155.83,184.17 NGFF1.35
USB31_TX_DP: length 2.1
  BOTTOM w0.102: CA247.2 156.85,184.55 155.96,184.55 155.83,184.67 NGFF1.37
USB_AGND: length 7.3
  TOP w0.229: R173.1 80.49,151.1 80.88,151.49 U25.36
  TOP w0.508: R173.1 80.49,149.59 CA49.2 C69.2 77.98,149.57 C71.2 76.42,149.52 FB46.1
USB_EN: length 67.2
  TOP w0.107: Q12.D 114.96,77.47 113.74,76.25 v1(113.74,71.45) ; v1(74.65,54.43) 74.6,54.48 RZU35.1
  IN1 w0.124: v1(74.65,54.43) 76.68,52.4 79.34,52.4 80.94,50.8 85.35,50.8 89.49,54.94 103.99,54.94 106.58,57.53 111.58,57.53 113.74,59.69 v1(113.74,71.45)
  BOTTOM w0.107: v1(74.65,54.43) RZ100.1
USB_EN#: length 5.6
  TOP w0.107: U14.4 124.05,75.62 123.47,76.2 122.58,76.2 121.92,76.86 RB47.1 121.63,76.82 Q12.G
USB_EN_R: length 23.4
  TOP w0.107: U22.3 92.9,58.94 92.58,58.62 v1(91.72,58.62)
  IN1 w0.124: v1(91.72,58.62) 91.72,57.99 90.25,56.52 87.76,56.52 v1(85.6,54.36)
  BOTTOM w0.107: v1(85.6,54.36) 85.3,54.65 77.75,54.65 77.39,54.3 U23.3 76.72,53.22 76.4,53.54 RZ100.2 74.63,52.55 RB58.1
USB_GND:
  vias: v1(82.93,184.91) v1(83.57,184.91)
USB_N0: length 2.1
  BOTTOM w0.102: NGFF1.9 155.83,177.67 155.96,177.55 156.69,177.55 FL1.2 157,177.85 RZ144.2
USB_OC0_N: length 16.4
  TOP w0.107: U22.4 95.13,58.94 94.82,59.26 94.82,63.3 96.55,65.02 96.55,69.72 95.83,70.43 RZ74.2
USB_OC1_N: length 27.5
  TOP w0.107: RZ103.1 v1(68.4,57.61) ; RZ95.2 v1(89.1,59.77)
  IN1 w0.124: v1(89.1,59.77) 89.1,58.93 84.71,54.53 v1(84.71,54.23) ; v1(68.4,57.61) 68.78,57.23 73.3,57.23 76.4,54.13 v1(79.76,54.13)
  BOTTOM w0.107: v1(84.71,54.23) 84.66,54.28 79.86,54.28 79.76,54.17 v1(79.76,54.13) 79.98,53.9 U23.4
USB_P0: length 2.1
  BOTTOM w0.102: NGFF1.7 155.83,177.17 155.96,177.29 156.69,177.29 FL1.3 157,176.99 RZ146.2
USBHUB_PLTRST_N: length 76.3
  TOP w0.107: U89.4 v1(116.73,110.44) ; RZ76.2 v1(73.86,74.12)
  IN1 w0.124: v1(73.86,74.12) 74.52,74.12 76.72,76.31 76.72,94.07 81.94,99.29 81.94,102.59 84.23,104.88 84.23,105.92 90.98,112.67 115.31,112.67 116.73,111.25 v1(116.73,110.44)
VP10_HUB: length 13.9
  TOP w0.203: U20.67 82.42,61.1 CA41.1 ; CA39.1 88.25,65.74 v1(87.91,65.74) 87.83,65.74 87.82,65.75 U20.8
  TOP w0.229: v1(82.5,71.75) 82.5,71.7 82.42,71.63 U20.29 ; U20.26 83.62,71.7 v1(83.57,71.75) ; v1(76.53,66.12) 76.96,66.55 U20.48 ; U20.72 v1(84.42,61.29) ; v1(76.28,62.43) 76.16,62.55 CA37.1 76.17,62.95 U20.57 ; v1(80.02,71.77) U20.35
  TOP w0.254: v1(84.42,61.29) 84.45,61.26 CA40.1 ; CA36.1 v1(76.53,66.12)
  TOP w0.305: CA34.1 79.63,72.16 v1(80.02,71.77) ; v1(82.5,71.75) 82.55,71.81 CA35.1 ; CA38.1 83.69,71.88 v1(83.57,71.75)
  vias: v1(81.94,60.53) v1(82.52,60.53)
VP10_MEM_A: length 4.5
  TOP w0.229: C62.1 74.08,67.98 74.68,68.58 76.83,68.58 77.27,68.15 U20.44
WDISABLE#1: length 2.6
  BOTTOM w0.107: R213.1 146.71,177.42 NGFF1.8
WDISABLE#2: length 3.6
  BOTTOM w0.107: NGFF1.26 146.33,181.92 R215.1 R216.1
WLAN_EN: length 2.7
  BOTTOM w0.254: U30.8 127.76,141.1 127.41,141.45 RZ167.2 R204.1
XOSCI: length 5
  TOP w0.107: U25.27 76.83,155.85 R176.1 75.37,155.47 C72.1 74.13,155.41 Y1.3
XOSCO: length 8.4
  TOP w0.107: Y1.1 72.1,157.82 72.39,158.12 74.42,158.12 74.68,157.86 74.68,156.84 74.89,156.63 C73.1 75.5,156.44 R176.2 76.65,156.25 U25.26
N16109: length 8.8
  TOP w0.107: J1.J51 97.26,130.1 97.26,132.23 97.05,132.44 97.05,138.35 RZU7.2
N19928: length 9.4
  TOP w0.254: R40.2 98.74,100.72 CA61.1 98.74,102.58 98.32,103 Q3.D 96.72,103.89 96.24,104.37 RZ32.1 RZU24.1 94.93,105.65 U9.1
N16629600: length 1.5
  BOTTOM w0.107: U43.12 36.22,31.72 36.2,31.75 35.45,31.75 R305.2
N16629602: length 1.5
  BOTTOM w0.107: R306.2 35.35,32.22 U43.13
N16629604: length 4.7
  BOTTOM w0.107: R307.2 35.31,35.17 35.31,33.53 36.11,32.72 U43.14
N16629606: length 3.9
  BOTTOM w0.107: R308.2 35.81,35.29 35.81,33.66 36.25,33.22 U43.15
N16629666: length 1.5
  BOTTOM w0.107: RA104.2 35.44,29.72 U43.8
N16629668: length 1.5
  TOP w0.107: RA40.2 36.51,27.25 v1(35.94,27.25)
  BOTTOM w0.107: U43.3 36.07,27.22 36.04,27.25 v1(35.94,27.25)
N16629670: length 1.5
  BOTTOM w0.107: RA116.2 35.43,28.72 U43.6
N16629672: length 1.5
  BOTTOM w0.107: U43.5 35.35,28.22 RA128.2
N16629674: length 1.5
  TOP w0.107: v1(35.94,29.22) 35.95,29.21 RA34.2
  BOTTOM w0.107: v1(35.94,29.22) U43.7
N16629676: length 1.6
  BOTTOM w0.107: U43.9 35.81,30.22 35.56,30.48 RA98.2
N16629678: length 1.5
  TOP w0.107: RA46.2 36.02,26.54 v1(35.94,26.62)
  BOTTOM w0.107: v1(35.94,26.62) 35.99,26.67 36.07,26.67 36.12,26.72 U43.2
N16629694: length 2
  BOTTOM w0.107: RA156.1 37.21,24 38.08,24.87 U43.63
N16629698: length 1.9
  BOTTOM w0.107: RA154.1 38.48,24 39.08,24.6 U43.61
N16629702: length 2
  BOTTOM w0.107: U43.62 38.58,24.73 37.85,24 RA155.1
N16629706: length 1.8
  BOTTOM w0.107: U43.60 39.58,24.46 39.12,24 RA153.1
N16629714: length 2.1
  BOTTOM w0.107: R301.1 37.34,35.81 38.08,35.08 U43.18
N16629874: length 1.7
  TOP w0.107: RA20.1 34.42,37.85 33.91,37.34 U44.3
N16629908: length 2.6
  TOP w0.107: v1(43.66,35.38) 43.66,35 43.94,34.72 R304.1
  BOTTOM w0.107: R303.1 43.69,35.41 v1(43.66,35.38) 43.58,35.3 U43.29
N16629916: length 1.5
  BOTTOM w0.107: U43.43 47.25,28.72 RA115.2
N16629918: length 1.7
  BOTTOM w0.107: U43.44 46.37,28.22 46.57,28.42 47.13,28.42 RA127.2
N16629942: length 5.2
  BOTTOM w0.203: X3.3 49.96,23.33 50.16,23.53 50.16,25.02 49.57,25.62 C182.1 49.16,26.44 R309.1 RB15.2
N16629964: length 2
  BOTTOM w0.107: U43.19 38.58,35.21 37.97,35.81 R302.1
N16629966: length 1.4
  TOP w0.107: U44.7 34.41,32.33 RA25.1
N16629970: length 1.6
  BOTTOM w0.107: U43.4 35.43,27.72 35.32,27.62 R300.1
N16633178: length 1.5
  BOTTOM w0.107: R329.2 53.73,31.75 54.48,31.75 54.51,31.72 U45.12
N16633180: length 1.5
  BOTTOM w0.107: U45.13 53.64,32.22 R330.2
N16633182: length 4.7
  BOTTOM w0.107: U45.14 54.4,32.72 53.59,33.53 53.59,35.17 R331.2
N16633184: length 3.9
  BOTTOM w0.107: R332.2 54.1,35.29 54.1,33.66 54.54,33.22 U45.15
N16633272: length 2
  BOTTOM w0.107: U45.63 56.36,24.87 55.5,24 RA152.1
N16633276: length 1.9
  BOTTOM w0.107: RA150.1 56.77,24 57.36,24.6 U45.61
N16633280: length 2
  BOTTOM w0.107: RA151.1 56.13,24 56.86,24.73 U45.62
N16633284: length 1.8
  BOTTOM w0.107: U45.60 57.86,24.46 57.4,24 RA149.1
N16633292: length 2.1
  BOTTOM w0.107: R325.1 55.63,35.81 56.36,35.08 U45.18
N16633452: length 1.3
  TOP w0.107: U46.3 52.2,37.7 RA21.1
N16633486: length 2.6
  TOP w0.107: v1(61.95,35.38) 61.95,35 62.23,34.72 R328.1
  BOTTOM w0.107: R327.1 61.98,35.41 v1(61.95,35.38) 61.86,35.3 U45.29
N16633520: length 5.2
  BOTTOM w0.203: X4.3 68.25,23.33 68.45,23.53 68.45,25.02 67.86,25.62 C191.1 67.45,26.44 R334.1 RB16.2
N16633542: length 2
  BOTTOM w0.107: U45.19 56.86,35.21 56.26,35.81 R326.1
N16633544: length 1.4
  TOP w0.107: RA26.1 52.7,32.33 U46.7
N16633548: length 1.6
  BOTTOM w0.107: R324.1 53.61,27.62 53.71,27.72 U45.4
N16636756: length 1.5
  BOTTOM w0.107: U47.12 72.8,31.72 72.77,31.75 72.26,31.75 72.14,31.62 R353.2
N16636758: length 1.5
  BOTTOM w0.107: U47.13 72.39,32.22 72.35,32.26 R354.2
N16636760: length 4.7
  BOTTOM w0.107: R355.2 71.88,35.17 71.88,33.53 72.69,32.72 U47.14
N16636762: length 3.9
  BOTTOM w0.107: U47.15 72.82,33.22 72.39,33.66 72.39,35.29 R357.2
N16636850: length 2
  BOTTOM w0.107: U47.63 74.65,24.87 73.79,24 RA148.1
N16636854: length 1.9
  BOTTOM w0.107: RA146.1 75.06,24 75.65,24.6 U47.61
N16636858: length 2
  BOTTOM w0.107: RA147.1 74.42,24 75.15,24.73 U47.62
N16636862: length 1.8
  BOTTOM w0.107: RA145.1 75.69,24 76.15,24.46 U47.60
N16636870: length 2.1
  BOTTOM w0.107: U47.18 74.65,35.08 73.91,35.81 R349.1
N16637030: length 1.8
  TOP w0.107: U48.3 70.49,37.84 70.35,37.99 RA18.1
N16637064: length 2.6
  TOP w0.107: R352.1 80.52,35.1 v1(80.24,35.38)
  BOTTOM w0.107: R351.1 80.26,35.41 v1(80.24,35.38) 80.15,35.3 U47.29
N16637098: length 5.2
  BOTTOM w0.203: X5.3 86.54,23.33 86.74,23.53 86.74,25.02 86.14,25.62 C200.1 85.74,26.44 R358.1 RB17.2
N16637120: length 2
  BOTTOM w0.107: R350.1 74.55,35.81 75.15,35.21 U47.19
N16637122: length 1.4
  TOP w0.107: RA27.1 71.03,32.6 70.99,32.64 U48.7
N16637126: length 1.9
  BOTTOM w0.107: R348.1 71.68,27.72 U47.4
N16640334: length 1.5
  BOTTOM w0.107: R377.2 90.42,31.62 90.55,31.75 91.06,31.75 91.09,31.72 U49.12
N16640336: length 1.5
  BOTTOM w0.107: U49.13 90.68,32.22 90.64,32.26 R378.2
N16640338: length 4.7
  BOTTOM w0.107: U49.14 90.98,32.72 90.17,33.53 90.17,35.17 R379.2
N16640340: length 3.9
  BOTTOM w0.107: R380.2 90.68,35.29 90.68,33.66 91.11,33.22 U49.15
N16640428: length 2
  BOTTOM w0.107: U49.63 92.94,24.87 92.08,24 RA144.1
N16640432: length 1.9
  BOTTOM w0.107: U49.61 93.94,24.6 93.34,24 RA142.1
N16640436: length 2
  BOTTOM w0.107: U49.62 93.44,24.73 92.71,24 RA143.1
N16640440: length 1.8
  BOTTOM w0.107: U49.60 94.44,24.46 93.98,24 RA141.1
N16640448: length 2.1
  BOTTOM w0.107: U49.18 92.94,35.08 92.2,35.81 R373.1
N16640608: length 1.3
  TOP w0.107: U50.3 88.78,37.34 88.76,37.35 RA22.1
N16640642: length 2.6
  TOP w0.107: R376.1 98.81,35.1 v1(98.53,35.38)
  BOTTOM w0.107: U49.29 98.44,35.3 v1(98.53,35.38) 98.55,35.41 R375.1
N16640676: length 5.2
  BOTTOM w0.203: RB18.2 R382.1 104.03,26.44 C209.1 104.43,25.62 105.03,25.02 105.03,23.57 104.83,23.37 104.37,23.37 X6.3
N16640698: length 2
  BOTTOM w0.107: U49.19 93.44,35.21 92.84,35.81 R374.1
N16640700: length 1.4
  TOP w0.107: U50.7 89.28,32.33 RA28.1
N16640704: length 1.5
  BOTTOM w0.107: R372.1 90.39,27.56 90.55,27.72 U49.4
N16643912: length 1.5
  BOTTOM w0.107: R401.2 108.71,31.62 108.84,31.75 109.35,31.75 109.38,31.72 U51.12
N16643914: length 1.5
  BOTTOM w0.107: U51.13 108.84,32.22 108.8,32.26 R402.2
N16643916: length 4.7
  BOTTOM w0.107: R403.2 108.46,35.17 108.46,33.53 109.26,32.72 U51.14
N16643918: length 3.9
  BOTTOM w0.107: U51.15 109.4,33.22 108.97,33.66 108.97,35.29 R404.2
N16644006: length 2
  BOTTOM w0.107: RA140.1 110.36,24 111.23,24.87 U51.63
N16644010: length 1.9
  BOTTOM w0.107: RA138.1 111.63,24 112.23,24.6 U51.61
N16644014: length 2
  BOTTOM w0.107: RA139.1 111,24 111.73,24.73 U51.62
N16644018: length 1.8
  BOTTOM w0.107: U51.60 112.73,24.46 112.27,24 RA137.1
N16644026: length 2.1
  BOTTOM w0.107: R397.1 110.49,35.81 111.23,35.08 U51.18
N16644186: length 1.6
  TOP w0.107: RA19.1 107.07,37.7 U52.3
N16644220: length 2.6
  TOP w0.107: R400.1 117.09,34.72 116.81,35 v1(116.81,35.38)
  BOTTOM w0.107: U51.29 116.73,35.3 v1(116.81,35.38) 116.84,35.41 R398.1
N16644254: length 5.2
  BOTTOM w0.203: X7.3 123.11,23.33 123.32,23.53 123.32,25.02 122.72,25.62 C218.1 122.31,26.44 R406.1 RB19.2
N16644276: length 2
  BOTTOM w0.107: U51.19 111.73,35.21 111.12,35.81 R399.1
N16644278: length 1.4
  TOP w0.107: U52.7 107.56,32.77 107.61,32.72 RA29.1
N16644282: length 1.5
  BOTTOM w0.107: U51.4 108.84,27.72 108.68,27.56 R396.1
N16647490: length 1.5
  BOTTOM w0.107: U53.12 127.66,32.1 127.64,32.13 126.89,32.13 R425.2
N16647492: length 1.5
  BOTTOM w0.107: U53.13 126.79,32.6 R426.2
N16647494: length 4.7
  BOTTOM w0.107: U53.14 127.55,33.1 126.75,33.91 126.75,35.55 R427.2
N16647496: length 3.9
  BOTTOM w0.107: U53.15 127.69,33.6 127.25,34.04 127.25,35.67 R428.2
N16647584: length 2
  BOTTOM w0.107: U53.63 129.52,25.25 128.65,24.38 RA136.1
N16647588: length 1.9
  BOTTOM w0.107: U53.61 130.52,24.98 129.92,24.38 RA134.1
N16647592: length 2
  BOTTOM w0.107: RA135.1 129.29,24.38 130.02,25.11 U53.62
N16647596: length 1.8
  BOTTOM w0.107: U53.60 131.02,24.84 130.56,24.38 RA133.1
N16647604: length 2.1
  BOTTOM w0.107: U53.18 129.52,35.46 128.78,36.2 R421.1
N16647764: length 1.7
  TOP w0.107: RA17.1 125.35,38.46 U54.3
N16647798: length 2.6
  TOP w0.107: R424.1 135.38,35.1 135.1,35.38 v1(135.1,35.76)
  BOTTOM w0.107: U53.29 135.02,35.68 v1(135.1,35.76) 135.13,35.79 R423.1
N16647832: length 4.9
  BOTTOM w0.203: X8.3 140.86,23.71 141.45,24.31 141.45,25.31 141.01,25.75 C227.1 140.6,26.82 R430.1 RB20.2
N16647854: length 2
  BOTTOM w0.107: U53.19 130.02,35.59 129.41,36.2 R422.1
N16647856: length 1.4
  TOP w0.107: U54.7 125.85,32.71 RA24.1
N16647860: length 1.6
  BOTTOM w0.107: U53.4 126.87,28.1 126.76,28 R420.1
N16651068: length 1.5
  BOTTOM w0.107: U55.12 129.31,43.72 129.29,43.69 129.29,42.94 R449.2
N16651070: length 1.5
  BOTTOM w0.107: U55.13 128.81,42.85 R450.2
N16651072: length 4.7
  BOTTOM w0.107: U55.14 128.31,43.6 127.51,42.8 125.87,42.8 R451.2
N16651074: length 3.9
  BOTTOM w0.107: R452.2 125.74,43.31 127.38,43.31 127.81,43.74 U55.15
N16651162: length 2
  BOTTOM w0.107: U55.63 136.17,45.57 137.03,44.7 RA61.1
N16651166: length 1.9
  BOTTOM w0.107: U55.61 136.44,46.57 137.03,45.97 RA59.1
N16651170: length 2
  BOTTOM w0.107: RA60.1 137.03,45.34 136.3,46.07 U55.62
N16651174: length 1.8
  BOTTOM w0.107: RA58.1 137.03,46.61 136.57,47.07 U55.60
N16651182: length 1.9
  BOTTOM w0.107: U55.18 125.96,45.57 125.09,44.7 R445.1
N16651342: length 1.5
  TOP w0.107: RA15.1 123.41,41.41 U56.3
N16651376: length 2.6
  TOP w0.107: v1(125.65,51.16) 126.03,51.16 126.31,51.44 R448.1
  BOTTOM w0.107: R446.1 125.63,51.18 v1(125.65,51.16) 125.74,51.07 U55.29
N16651410: length 5.1
  BOTTOM w0.203: R453.1 RB21.2 133.73,56.5 C236.1 133.64,56.63 132.79,57.48 132.79,58.62 133.34,59.17 X9.3
N16651432: length 1.8
  BOTTOM w0.107: R447.1 125.09,45.34 125.82,46.07 U55.19
N16651434: length 1.4
  TOP w0.107: RA14.1 128.71,41.91 U56.7
N16651438: length 1.6
  BOTTOM w0.107: R444.1 133.42,42.81 133.31,42.92 U55.4
N16705548: length 14.1
  TOP w0.254: U92.19 47.85,145.32 47.75,145.41 CA53.2
  TOP w0.508: v1(48.01,144.27) R727.2 47.35,145.4 CA53.2
  IN3 w0.508: v1(48.01,144.27) 46.99,144.27 44.96,146.3 44.96,151.13 v1(43.56,152.53)
N16706602: length 15
  TOP w0.254: 47.55,148.54 48.21,148.54 48.43,148.32 U92.13
  TOP w0.508: Q44.4 36.37,151.21 37.21,150.37 43.56,150.37 45.39,148.54 47.55,148.54
N16715221: length 23.9
  TOP w0.254: R737.1 5.56,116.81 v1(5.92,116.46)
  TOP w0.279: v1(10.36,116.54) 10.44,116.46 U83.36
  IN3 w0.254: v1(5.92,116.46) 5.77,116.61 5.77,117.37 6.63,118.24 10.22,118.24 10.92,118.95 10.92,123.95 12.4,125.43 12.4,126.26 12.85,126.72 13.49,126.72 v2(13.97,126.24)
  BOTTOM w0.508: v2(12.19,120.4) 9.75,117.96 C472.1 9.75,117.14 v1(10.36,116.54)
  vias: v2(12.7,124.21) v2(12.7,123.44) v2(12.7,122.68) v2(12.7,121.92) v2(12.7,121.16) v2(12.95,120.4) v2(13.72,120.4) v2(14.48,120.4) v2(14.73,126.24) v2(15.24,120.4) v2(15.49,126.24) v2(16,120.4) v2(16.26,126.24) v2(16.76,120.4) v2(17.02,126.24) v2(17.53,120.4) v2(17.78,126.24)
N16715269: length 18.1
  TOP w0.254: v1(5.23,116.46) 5.56,116.13 R738.1
  IN3 w0.254: v1(5.23,116.46) 5.38,116.61 5.38,117.53 6.48,118.62 10.06,118.62 10.54,119.11 10.54,124.11 12.01,125.58 12.01,126.42 12.69,127.1 13.51,127.1 v2(13.97,127.56)
  vias: v2(12.45,134.87) v2(12.45,134.11) v2(12.57,132.59) v2(12.57,131.7) v2(12.57,130.81) v2(12.57,129.92) v2(12.57,129.03) v2(13.34,134.87) v2(13.34,134.11) v2(14.22,134.87) v2(14.22,134.11) v2(14.86,127.56) v2(15.11,134.87) v2(15.11,134.11) v2(15.75,127.56) v2(16,134.87) v2(16,134.11) v2(16.64,127.56) v2(16.89,134.87) v2(16.89,134.11) v2(17.53,127.56) v2(17.78,134.87) v2(17.78,134.11)
N16715333: length 14.3
  TOP w0.279: v1(11.63,116.54) 11.63,116.41 11.44,116.21 U83.34
  TOP w0.508: v1(12.4,127.74) 12.62,127.51 R735.1
  IN1 w0.508: v1(12.4,127.74) 12.27,127.61 12.27,125.45 10.92,124.1 10.92,118.03 11.63,117.32 v1(11.63,116.54)
N16715396: length 15.7
  TOP w0.279: U83.25 15.94,116.93 C473.1
  TOP w0.508: C473.1 16.56,118.08 17.14,118.67 26.85,118.67 28.4,120.22
  vias: v2(24.21,134.95) v2(24.21,134.19) v2(25.1,134.95) v2(25.1,134.19) v2(25.98,134.95) v2(25.98,134.19) v2(26.87,134.95) v2(26.87,134.19) v2(27.76,134.95) v2(27.76,134.19) v2(30.18,120.47) v2(30.18,119.71) v2(31.06,129.11) v2(31.06,128.22) v2(31.06,127.33) v2(31.06,126.44) v2(31.06,120.47) v2(31.06,119.71) v2(31.95,129.11) v2(31.95,128.22) v2(31.95,127.33) v2(31.95,126.44) v2(31.95,120.47) v2(31.95,119.71) v2(32.84,129.11) v2(32.84,128.22) v2(32.84,127.33) v2(32.84,126.44) v2(32.84,120.47) v2(32.84,119.71) v2(33.73,129.11) v2(33.73,128.22) v2(33.73,127.33) v2(33.73,126.44) v2(33.73,120.47) v2(33.73,119.71)
N16716334: length 6.6
  TOP w0.254: RZ24.1 22.89,117.07 26.51,117.07 26.79,117.35 27.3,117.35 v1(27.51,117.55)
  BOTTOM w0.254: R730.1 v1(27.51,117.55)
  vias: v2(22.61,127) v2(22.61,126.24) v2(22.99,120.47) v2(22.99,119.74) v2(23.37,127) v2(23.37,126.24) v2(23.75,120.47) v2(24.13,127) v2(24.13,126.24) v2(24.51,120.47) v2(24.89,127) v2(24.89,126.24) v2(25.27,120.47) v2(25.65,127) v2(25.65,126.24) v2(26.04,120.47) v2(26.04,119.74) v2(26.42,127) v2(26.42,126.24)
N16716474: length 2.4
  TOP w0.279: U83.35 10.94,116.47 v1(11,116.54)
  BOTTOM w0.508: v1(11,116.54) 11,117.45 C472.2
N16716845: length 5.8
  TOP w0.254: U83.38 9.44,116.14 9.25,116.33 8,116.33 7.49,115.82 C470.1 6.45,115.06 6.2,114.81 R738.2
N16716849: length 6.4
  TOP w0.254: R737.2 6.15,118.19 6.48,117.86 C470.2 7.49,117.22 8,116.71 9.4,116.71 9.94,116.18 U83.37
N16717006: length 3
  TOP w0.508: Q45.4 11.43,125.43 v1(11.43,125.98) 11.63,126.19 11.63,126.8 R735.2
  BOTTOM w0.508: C919.2 12.19,125.22 v1(11.43,125.98)
N16717017: length 2.8
  TOP w0.508: R739.2 v1(28.42,126.19) 28.42,125.5 Q46.4
  BOTTOM w0.508: C467.1 28.52,126.29 v1(28.42,126.19)
N16717021: length 22.6
  TOP w0.279: U83.27 v1(14.94,116.54)
  TOP w0.508: R739.1 v1(27.46,126.24)
  IN1 w0.508: v1(27.46,126.24) 27.46,118.87 25.12,116.54 v1(14.94,116.54)
N16717190: length 2.4
  TOP w0.508: R749.1 36.83,125.27 Q48.4
N16717194: length 36.3
  TOP w0.279: U83.29 v1(13.94,116.54)
  TOP w0.508: R749.2 v1(36.09,127.86)
  IN1 w0.508: v1(13.94,116.54) 13.94,115.57 14.44,115.06 19.02,115.06 19.76,114.33 26.19,114.33 29.82,117.96 35.03,117.96 35.71,118.64 35.71,127.48 v1(36.09,127.86)
N16717547: length 1.7
  TOP w0.508: R744.1 19.71,126.19 19.63,126.11 Q47.4
N16717551: length 16.6
  TOP w0.279: U83.32 v1(12.44,116.54)
  TOP w0.508: R744.2 v1(20.68,126.24)
  IN1 w0.508: v1(12.44,116.54) 13.2,117.3 14.07,117.3 15.52,118.75 17.6,118.75 18.52,119.66 18.52,124.08 v1(20.68,126.24)
N16717863: length 2.3
  TOP w0.279: U83.26 15.44,117.2 C473.2
N16719242: length 6.1
  TOP w0.254: RZ24.2 19.86,117.6 C918.2 19.29,117.11 17.66,117.11 16.94,116.38 U83.23
N16719249: length 5.3
  TOP w0.254: RZ26.2 20.07,116.33 C918.1 19.37,116.73 17.82,116.73 17.44,116.34 U83.22
N16719556: length 4.7
  TOP w0.279: 18.62,108.28 18.62,108.66 18.44,108.84 U83.19
  TOP w0.508: 18.62,108.28 18.62,107.62 R731.1 19.15,107.54 v1(20.02,108.41)
  BOTTOM w0.381: R733.2 20.07,108.46 v1(20.02,108.41)
N16830344: length 4.4
  TOP w0.508: RZ49.1 C419.2 126.77,100.43 v1(126.87,100.33) 126.9,100.3 RZ118.2
  BOTTOM w0.508: Q40.4 v1(126.87,100.33)
N16830441: length 7.5
  TOP w0.508: RZ49.2 124.23,102.23 124.46,102.46 Q42.D 123.98,103.76 123.34,104.39 123.34,106.93 123.07,107.2 Q41.G
N16830443: length 4.1
  TOP w0.508: R704.2 126.14,104.17 R703.2 Q41.D
N16830501: length 2.5
  TOP w0.381: Q42.G 121.96,104.41 121.79,104.24 RZ121.2 RZ45.2
N16831259: length 4.2
  BOTTOM w0.229: R711.1 84.19,102.02 U78.1
  BOTTOM w0.508: R705.2 85.51,103.24 C424.2 R711.1
N16831562: length 3.1
  TOP w0.254: 51.03,143.64 51.03,144.02 51.3,144.29 U92.1
  TOP w0.508: R718.2 R719.1 51.03,143.64
N16831739: length 5
  TOP w0.254: 50.06,143.64 50.06,144 49.8,144.27 U92.20
  TOP w0.508: v1(48.87,143.84) R720.2 R719.2 50.06,143.64
  BOTTOM w0.508: C436.1 49,143.97 v1(48.87,143.84)
N16832049: length 1.4
  TOP w0.254: U92.2 v1(52.2,144.78)
  BOTTOM w0.508: v1(52.2,144.78) 52.53,145.11 R723.2
N16832178: length 2.2
  TOP w0.254: 53.42,145.36 52.96,145.82 U92.3
  TOP w0.508: C444.1 53.42,145.36
N16832533: length 2.6
  TOP w0.254: U92.4 53.49,146.32 C446.1
  TOP w0.508: C446.1 54.74,146.22 C441.1
N16832601: length 1.1
  TOP w0.508: R725.2 55.73,146.19 C441.2
N16833149: length 1.2
  TOP w0.508: C440.1 55.74,150.72 R721.1
N16833152: length 6.2
  TOP w0.254: C446.2 53.26,146.82 U92.5
  TOP w0.508: C440.2 54.76,150.74 R722.1 R726.2 R725.1 53.76,147.32 C446.2
N16834080: length 1.7
  TOP w0.254: R724.2 47.75,146.56 47.99,146.32 U92.17
N16834083: length 1.1
  TOP w0.508: R724.1 46.39,146.55 CA53.1
N16834553: length 1.5
  TOP w0.107: RA47.2 54.31,26.54 v1(54.23,26.62)
  BOTTOM w0.107: v1(54.23,26.62) 54.28,26.67 54.36,26.67 54.41,26.72 U45.2
N16834556: length 1.5
  TOP w0.107: v1(54.23,27.25) 54.79,27.25 RA41.2
  BOTTOM w0.107: v1(54.23,27.25) 54.33,27.25 54.36,27.22 U45.3
N16834559: length 1.5
  BOTTOM w0.107: U45.6 53.71,28.72 RA114.2
N16834562: length 1.5
  BOTTOM w0.107: RA126.2 53.63,28.22 U45.5
N16834578: length 1.5
  TOP w0.107: RA35.2 54.24,29.21 v1(54.23,29.22)
  BOTTOM w0.107: v1(54.23,29.22) U45.7
N16834580: length 1.6
  BOTTOM w0.107: RA97.2 53.84,30.48 54.1,30.22 U45.9
N16834582: length 1.5
  BOTTOM w0.107: RA103.2 53.73,29.72 U45.8
N16834584: length 1.5
  BOTTOM w0.107: U45.43 65.54,28.72 RA113.2
N16834593: length 1.7
  BOTTOM w0.107: RA125.2 65.42,28.42 64.85,28.42 64.66,28.22 U45.44
N16835211: length 13.3
  TOP w0.254: U92.11 49.8,150.7 C457.2
  TOP w0.508: R727.1 v1(45.72,144.27) ; C457.2 v1(49.75,151.38)
  IN1 w0.508: v1(49.75,151.38) 49.75,150.71 49.28,150.24 46.48,150.24 45.72,149.48 v1(45.72,144.27)
N16835305: length 2.6
  TOP w0.254: U92.14 48.17,147.82 v1(48.08,147.9)
  BOTTOM w0.508: C458.1 49,148.82 v1(48.08,147.9)
N16836271: length 25.2
  TOP w0.254: U92.18 v1(48.13,145.82)
  TOP w0.508: Q43.4 v2(43.31,162.69)
  IN3 w0.508: v2(43.31,162.69) 48.03,162.69 48.72,162 48.72,152.96 46.99,151.23 46.99,146.65 47.83,145.82 v1(48.13,145.82)
N16840068: length 1.5
  TOP w0.107: v1(90.81,26.62) 90.88,26.54 RA49.2
  BOTTOM w0.107: v1(90.81,26.62) 90.91,26.72 U49.2
N16840070: length 1.5
  TOP w0.107: RA43.2 90.86,27.3 v1(90.81,27.25)
  BOTTOM w0.107: v1(90.81,27.25) 90.83,27.22 U49.3
N16840072: length 1.5
  BOTTOM w0.107: RA110.2 90.44,28.83 90.55,28.72 U49.6
N16840074: length 1.5
  BOTTOM w0.107: RA122.2 90.21,28.22 U49.5
N16840076: length 1.5
  TOP w0.107: v1(90.81,29.22) 90.82,29.21 RA37.2
  BOTTOM w0.107: v1(90.81,29.22) U49.7
N16840078: length 1.6
  BOTTOM w0.107: U49.9 90.68,30.22 90.42,30.48 RA95.2
N16840080: length 1.5
  BOTTOM w0.107: RA101.2 90.43,29.84 90.55,29.72 U49.8
N16840082: length 1.5
  BOTTOM w0.107: U49.43 101.73,28.72 101.83,28.83 RA109.2
N16840084: length 1.7
  BOTTOM w0.107: U49.44 101.12,28.22 101.32,28.42 102,28.42 RA121.2
N16841727: length 1.5
  TOP w0.107: v1(109.09,26.62) 109.17,26.54 RA50.2
  BOTTOM w0.107: U51.2 109.2,26.72 v1(109.09,26.62)
N16841729: length 1.5
  TOP w0.107: RA44.2 109.66,27.25 v1(109.09,27.25)
  BOTTOM w0.107: v1(109.09,27.25) 109.12,27.22 U51.3
N16841731: length 1.5
  BOTTOM w0.107: U51.6 108.97,28.72 108.86,28.83 RA108.2
N16841733: length 1.5
  BOTTOM w0.107: RA120.2 108.94,28.19 108.97,28.22 U51.5
N16841735: length 1.5
  TOP w0.107: RA38.2 109.1,29.21 v1(109.09,29.22)
  BOTTOM w0.107: v1(109.09,29.22) U51.7
N16841737: length 1.6
  BOTTOM w0.107: U51.9 108.97,30.22 108.71,30.48 RA94.2
N16841739: length 1.5
  BOTTOM w0.107: RA100.2 108.84,29.84 108.97,29.72 U51.8
N16841741: length 1.5
  BOTTOM w0.107: U51.43 120.4,28.72 RA107.2
N16841743: length 1.7
  BOTTOM w0.107: RA119.2 120.29,28.42 119.6,28.42 119.41,28.22 U51.44
N16843394: length 1.5
  TOP w0.107: RA45.2 127.46,26.92 v1(127.38,27)
  BOTTOM w0.107: U53.2 127.56,27.1 127.51,27.05 127.43,27.05 v1(127.38,27)
N16843396: length 1.5
  TOP w0.107: RA39.2 127.95,27.63 v1(127.38,27.63)
  BOTTOM w0.107: U53.3 127.51,27.6 127.48,27.63 v1(127.38,27.63)
N16843398: length 1.5
  BOTTOM w0.107: U53.6 126.87,29.1 RA106.2
N16843400: length 1.5
  BOTTOM w0.107: RA118.2 126.79,28.6 U53.5
N16843402: length 1.5
  TOP w0.107: RA32.2 127.39,29.59 v1(127.38,29.6)
  BOTTOM w0.107: v1(127.38,29.6) U53.7
N16843404: length 1.6
  BOTTOM w0.107: RA93.2 127,30.86 127.25,30.6 U53.9
N16843406: length 1.5
  BOTTOM w0.107: U53.8 126.88,30.1 RA99.2
N16843408: length 1.5
  BOTTOM w0.107: RA105.2 138.69,29.1 U53.43
N16843410: length 1.7
  BOTTOM w0.107: RA117.2 138.57,28.8 138.01,28.8 137.81,28.6 U53.44
N16845078: length 1.5
  TOP w0.107: v1(134.42,43.43) 134.37,43.48 RA13.2
  BOTTOM w0.107: U55.2 134.31,43.61 134.37,43.56 134.37,43.48 v1(134.42,43.43)
N16845083: length 1.5
  TOP w0.107: RA12.2 133.6,43.62 v1(133.79,43.43)
  BOTTOM w0.107: U55.3 133.81,43.56 133.79,43.54 v1(133.79,43.43)
N16845085: length 1.5
  BOTTOM w0.107: RA63.2 132.31,42.92 U55.6
N16845087: length 1.5
  BOTTOM w0.107: RA62.2 132.81,42.84 U55.5
N16845090: length 1.5
  TOP w0.107: v1(131.81,43.43) 131.7,43.55 RA11.2
  BOTTOM w0.107: v1(131.81,43.43) U55.7
N16845094: length 1.6
  BOTTOM w0.107: U55.9 130.81,43.31 130.56,43.05 RA65.2
N16845096: length 1.5
  BOTTOM w0.107: U55.8 131.31,42.93 RA64.2
N16845099: length 1.5
  BOTTOM w0.107: U55.43 132.31,54.74 RA54.2
N16845103: length 1.7
  BOTTOM w0.107: U55.44 132.81,53.86 132.62,54.06 132.62,54.63 RA53.2
N16849261: length 2.1
  TOP w0.279: U83.11 14.44,107.71 R741.2
N16849480: length 2.1
  TOP w0.279: U83.7 12.44,107.66 RB29.1
N16849547: length 2.3
  TOP w0.279: U83.10 13.94,108.02 RZ31.2
N16849713: length 2.2
  TOP w0.279: U83.15 16.44,108.71 16.57,108.57 v1(16.57,108.47)
  BOTTOM w0.381: R753.2 16.05,109.19 16.57,108.67 v1(16.57,108.47)
N16849718: length 2
  TOP w0.279: U83.14 15.94,108.5 v1(15.98,108.46)
  BOTTOM w0.381: R752.2 15.98,107.82 v1(15.98,108.46)
N16849723: length 2.1
  TOP w0.279: U83.13 15.44,108.5 v1(15.39,108.46)
  BOTTOM w0.381: R751.2 14.81,109.04 v1(15.39,108.46)
N16849728: length 1.6
  BOTTOM w0.381: R747.1 19.05,107.85 C476.2
N16940595: length 18
  TOP w0.508: CA107.1 CA106.1 CA105.1 95,16.68 v1(94.96,16.64) ; CA107.1 97.92,16.68 v1(97.96,16.64) ; CA107.1 C258.1 ; C258.1 100.97,16.64 v1(100.96,16.64) ; C258.1 CA108.1 104.01,16.69 v1(103.96,16.64)
  BOTTOM w0.508: U61.1 v1(94.96,16.64) ; U61.7 v1(100.96,16.64) ; U61.4 v1(97.96,16.64) ; U61.10 v1(103.96,16.64)
N16940606: length 1.9
  TOP w0.813: R476.2 C259.1
N16940607: length 1.9
  TOP w0.813: R477.2 103.38,10.13 C260.1
N16940608: length 1.9
  TOP w0.813: R478.2 C261.1
N16940609: length 1.9
  TOP w0.813: R479.2 C262.1
N16940656: length 18
  TOP w0.508: v1(124.15,16.64) 124.21,16.69 CA112.1 C263.1 ; C263.1 CA111.1 ; C263.1 121.16,16.64 v1(121.15,16.64) ; v1(115.15,16.64) 115.19,16.68 CA109.1 CA110.1 CA111.1 ; CA111.1 118.11,16.68 v1(118.15,16.64)
  BOTTOM w0.508: U62.4 v1(118.15,16.64) ; U62.1 v1(115.15,16.64) ; U62.10 v1(124.15,16.64) ; U62.7 v1(121.15,16.64)
N16940667: length 1.9
  TOP w0.813: C264.1 127.48,8.26 R480.2
N16940668: length 2
  TOP w0.813: R481.2 123.55,8.26 C265.1
N16940669: length 2
  TOP w0.813: R482.2 C266.1
N16940670: length 1.9
  TOP w0.813: R483.2 C267.1
N16942353: length 18.5
  TOP w0.508: C273.1 CA85.1 ; C273.1 142.49,50.55 v1(142.49,50.54) ; C273.1 CA81.1 142.44,53.59 v1(142.49,53.54) ; CA85.1 CA86.1 CA87.1 141.61,44.54 v1(142.47,44.54) ; CA85.1 v1(142.46,47.5)
  BOTTOM w0.508: U64.1 v1(142.47,44.54) ; U64.7 v1(142.49,50.54) ; U64.10 v1(142.49,53.54) ; v1(142.46,47.5) 142.42,47.54 U64.4
N16942364: length 2.1
  TOP w0.813: C274.1 150.37,56.16 R488.2
N16942365: length 1.9
  TOP w0.813: C275.1 150.75,51.33 R489.2
N16942366: length 2
  TOP w0.813: R490.2 148.82,49.02 C276.1
N16942367: length 2.3
  TOP w0.813: R491.2 150.06,45.8 149.35,45.09 C277.1
N16942442: length 2
  TOP w0.813: R484.2 147.68,8.33 C269.1
N16942443: length 1.9
  TOP w0.813: R485.2 143.74,8.26 C270.1
N16942444: length 1.9
  TOP w0.813: R486.2 139.8,8.26 C271.1
N16942445: length 1.9
  TOP w0.813: R487.2 C272.1
N17059986: length 5.5
  TOP w0.107: RZ148.2 63.75,174.02 63.75,176.78 63.53,177.01 RB3.2 63.11,177.02 U36.1
N17062477: length 5.4
  TOP w0.107: v1(116.15,43.56) 116.15,42.88 RZ119.1
  BOTTOM w0.107: SW2.1 v1(116.15,43.56) SW2.2
N17062487: length 5.4
  TOP w0.107: v1(118.55,43.56) 118.55,42.88 RZ112.1
  BOTTOM w0.107: SW1.1 v1(118.55,43.56) SW1.2
N17062540: length 1.8
  TOP w0.254: U13.21 v1(139.33,76.96)
  BOTTOM w0.254: v1(139.33,76.96) 139.32,76.95 RZ199.1
N17062551: length 3.9
  TOP w0.254: C25.1 136.53,76.86 136.83,76.56 U13.26
  TOP w0.508: R84.1 135.52,78.27 C25.1
N17068458: length 9
  TOP w0.508: U40.11 35.63,188.09 35.25,187.71 29.59,187.71 29.28,188.02 U40.16
N17071169: length 3.7
  TOP w0.107: RZU1.1 33.35,190.84 v1(33.09,190.58) U40.13
  BOTTOM w0.254: v1(33.09,190.58) 33.02,190.65 FL2.1
N17071172: length 4
  TOP w0.107: U40.12 34.36,190.57 v1(34.37,190.58) 34.37,191.24 RZU2.1
  BOTTOM w0.254: FL2.2 34.44,190.65 v1(34.37,190.58)
N17071866: length 4.5
  TOP w0.508: C163.1 v1(28.83,191.26)
  BOTTOM w0.508: v1(28.83,191.26) 29.21,190.88 R264.1 R267.2
N17107581: length 1.7
  BOTTOM w0.508: R22.2 D1.A1
N17475821: length 19.5
  TOP w0.508: v1(15.11,20.07) 15.06,20.12 CA90.1 ; CA91.1 CA90.1 ; CA91.1 C239.1 CA92.1 22.68,20.12 v1(22.73,20.07) ; CA91.1 18.87,20.12 v1(18.92,20.07) ; CA90.1 CA89.1 12.05,20.82 v1(11.3,20.07)
  BOTTOM w0.508: U57.7 v1(18.92,20.07) ; U57.1 v1(11.3,20.07) ; U57.4 v1(15.11,20.07) ; U57.10 v1(22.73,20.07)
N17477312: length 18
  TOP w0.508: C243.1 CA95.1 ; C243.1 40.39,16.64 v1(40.38,16.64) ; C243.1 CA96.1 43.43,16.69 v1(43.38,16.64) ; CA95.1 37.34,16.68 v1(37.38,16.64) ; CA95.1 CA94.1 CA93.1 34.42,16.68 v1(34.38,16.64)
  BOTTOM w0.508: U58.10 v1(43.38,16.64) ; U58.7 v1(40.38,16.64) ; U58.4 v1(37.38,16.64) ; U58.1 v1(34.38,16.64)
N17477531:
  vias: v1(40.82,11.23) v1(41.43,11.23)
N17477559:
  vias: v1(44.68,11.23) v1(45.31,11.23)
N17486236: length 18
  TOP w0.508: v1(63.57,16.64) 63.63,16.69 CA100.1 C248.1 ; C248.1 60.58,16.64 v1(60.57,16.64) ; C248.1 CA99.1 ; CA99.1 57.53,16.68 v1(57.57,16.64) ; CA99.1 CA98.1 CA97.1 54.61,16.68 v1(54.57,16.64)
  BOTTOM w0.508: U59.7 v1(60.57,16.64) ; U59.10 v1(63.57,16.64) ; U59.4 v1(57.57,16.64) ; U59.1 v1(54.57,16.64)
N17486352:
  vias: v1(60.96,11.23) v1(61.57,11.23)
N17486475:
  vias: v1(64.87,11.23) v1(65.51,11.23)
N17486917: length 18
  TOP w0.508: CA103.1 CA102.1 CA101.1 74.8,16.68 v1(74.76,16.64) ; CA103.1 C253.1 ; CA103.1 77.72,16.68 v1(77.76,16.64) ; v1(80.76,16.64) 80.77,16.64 C253.1 ; C253.1 CA104.1 83.82,16.69 v1(83.76,16.64)
  BOTTOM w0.508: U60.7 v1(80.76,16.64) ; U60.4 v1(77.76,16.64) ; U60.10 v1(83.76,16.64) ; U60.1 v1(74.76,16.64)
N17487128:
  vias: v1(81.13,11.23) v1(81.74,11.23)
N17487156:
  vias: v1(85.06,11.23) v1(85.7,11.23)
N17488314:
  vias: v1(101.32,11.23) v1(101.93,11.23)
N17488336:
  vias: v1(105.26,11.23) v1(105.89,11.23)
N17488976:
  vias: v1(121.49,11.23) v1(122.1,11.23)
N17489028:
  vias: v1(125.45,11.23) v1(126.09,11.23)
N17489888:
  vias: v1(145.64,11.23) v1(146.28,11.23)
N17489893:
  vias: v1(141.81,11.23) v1(142.42,11.23)
N17490600:
  vias: v1(147.65,58.01) v1(147.65,57.38)
N17490605:
  vias: v1(147.4,53.01) v1(147.4,52.4)
N17490610:
  vias: v1(147.42,47.85) v1(147.42,47.22)
N17490615:
  vias: v1(147.65,43.69) v1(147.65,43.05)
N17518837: length 4.1
  TOP w0.107: UNK@U28.3 71.31,54.54 72.09,55.32 RZU35.2 RB59.2
N17518839: length 3.3
  TOP w0.107: UNK@U28.5 67.59,53.59 67.26,53.92 R181.2
N17518846: length 1.4
  TOP w0.107: RZ103.2 68.4,54.57 UNK@U28.4
N17525472: length 6.5
  BOTTOM w0.508: U27.3 78.78,179.45 82.17,179.45 82.7,178.92 R177.1
N17533418: length 2.4
  TOP w0.508: U24.7 93.37,177.9 93.5,177.77 RB2.2
N17533420: length 2.2
  TOP w0.508: U24.10 93.37,190.25 93.5,190.37 RB1.2
N17533862: length 2.3
  BOTTOM w0.508: U26.7 87.02,178.18 86.84,178 RB61.2
N17533864: length 2.3
  BOTTOM w0.508: U26.10 87.02,190.07 86.84,190.25 RB60.2
N17921140: length 3.1
  TOP w0.089: CB155.1 99.44,91.5 99.44,91.25 99.15,90.96 98.36,90.96 97.84,90.44 97.84,90.25 97.89,90.19 U66.50
N17921144: length 3.1
  TOP w0.089: CB156.1 99.16,91.5 99.16,91.36 99.03,91.24 98.25,91.24 97.56,90.55 97.56,90.25 97.49,90.18 U66.51
N17921205: length 2.4
  TOP w0.089: CB157.1 97.36,91.5 97.36,91.29 97.11,91.03 96.88,91.03 96.63,90.79 96.63,90.24 96.69,90.18 U66.53
N17921207: length 2.4
  TOP w0.089: U66.54 96.29,90.18 96.35,90.24 96.35,90.91 96.76,91.31 96.99,91.31 97.08,91.4 97.08,91.5 CB158.1
N17921252: length 1.7
  TOP w0.089: CB159.1 95.83,91.25 95.83,90.22 95.89,90.16 U66.55
N17921254: length 1.7
  TOP w0.089: CB160.1 95.55,91.25 95.55,90.23 95.49,90.17 U66.56
N17921286: length 1.7
  TOP w0.089: U66.59 94.29,90.2 94.35,90.26 94.35,91.18 CB162.1
N17921288: length 1.7
  TOP w0.089: CB161.1 94.63,91.32 94.63,90.25 94.69,90.19 U66.58
N17921312: length 8.3
  TOP w0.107: Y2.1 93.28,96.56 94.05,95.79 94.05,94.29 93.93,94.16 93.22,94.16 92.47,93.41 C293.1 92.48,93.21 R525.1 92.61,92.02 92.61,90.34 92.69,90.26 U66.63
N17921343: length 5.9
  TOP w0.107: U66.64 92.29,91.37 R525.2 91.52,92.95 C295.1 91.53,93.5 91.53,94.4 Y2.3
N17924096: length 3.8
  TOP w0.203: U66.15 90.35,83.33 90.13,83.12
  TOP w0.508: R534.1 89,82.79 C297.2 89.81,82.8 90.13,83.12
N17924979: length 3.7
  TOP w0.203: 101.6,86.13 101.45,86.28 99.98,86.28 99.83,86.13 U66.41
  TOP w0.381: R509.2 101.6,86.13
  TOP w0.508: R509.2 101.64,86.09 C289.1
N17925260: length 2.4
  TOP w0.508: C289.2 102.59,84.98 R509.1 103.75,86.11 C288.1
N17925590: length 4.4
  TOP w0.203: U66.33 99.48,82.93 99.75,82.66
  TOP w0.483: 99.75,82.66 100.86,81.55 CB20.2 103.04,81.55 R512.1
N17925618: length 1.5
  TOP w0.508: R512.2 104.01,81.05 104.34,80.72 C290.1
N17945769: length 1.9
  BOTTOM w0.107: U38.2 RZ145.2
N17954676: length 18
  TOP w0.508: v1(138.34,16.64) 138.3,16.68 CA115.1 ; v1(141.34,16.64) 141.35,16.64 CA116.1 ; CA116.1 C268.1 144.4,16.69 v1(144.34,16.64) ; CA116.1 CA115.1 ; v1(135.34,16.64) 135.38,16.68 CA113.1 CA114.1 CA115.1
  BOTTOM w0.508: v1(135.34,16.64) U63.1 ; U63.4 v1(138.34,16.64) ; U63.7 v1(141.34,16.64) ; U63.10 v1(144.34,16.64)
N17962248: length 1.7
  TOP w0.229: U65.55 11.76,80.16 RZ63.1
N17962251: length 1.6
  TOP w0.229: RZ64.1 12.26,80.36 U65.54
N17978352: length 2.4
  TOP w0.114: v3(66.36,86.62) 66.65,86.33 66.65,85.41 CM46.1
  BOTTOM w0.114: v3(66.36,86.62) 65.96,87.02 U67.U25
N17978356: length 2.4
  TOP w0.114: CM47.1 66.9,85.46 66.9,86.36 v3(67.16,86.62)
  BOTTOM w0.114: U67.V25 v3(67.16,86.62)
N17978406: length 2.7
  BOTTOM w0.114: U67.W26 67.83,85.94 67.83,84.18 CM78.1
N17978410: length 2.7
  BOTTOM w0.114: U67.Y26 68.09,85.95 68.09,84.15 CM77.1
N17979269: length 2.7
  BOTTOM w0.114: U67.M26 61.8,86.22 61.69,86.1 61.69,84.32 CM73.1
N17979281: length 2.7
  BOTTOM w0.114: U67.L26 61.32,86.22 61.43,86.1 61.43,84.26 CM74.1
N17979323: length 2.7
  BOTTOM w0.114: U67.H26 58.6,86.22 58.49,86.1 58.49,84.3 CM75.1
N17979335: length 2.7
  BOTTOM w0.114: CM76.1 58.23,84.28 58.23,86.1 58.12,86.22 U67.G26
N17979425: length 3.6
  TOP w0.114: CM49.1 56.29,84.32 56.29,85.9 56.49,86.1 56.49,86.34 v3(56.76,86.62)
  BOTTOM w0.114: U67.F25 57.16,87.02 v3(56.76,86.62)
N17979437: length 3.6
  TOP w0.114: v3(55.96,86.62) 56.23,86.34 56.23,86.21 56.03,86.01 56.03,84.26 CM48.1
  BOTTOM w0.114: U67.E25 56.36,87.02 v3(55.96,86.62)
N17981424: length 3.6
  BOTTOM w0.114: RZ183.1 75.02,103.82 73.85,103.82 73.45,103.43 72.77,103.43 U67.AE5
N17981427: length 3.6
  BOTTOM w0.114: RZ184.1 75.02,103.57 74.78,103.57 74.67,103.46 74.67,103.13 74.56,103.02 74.4,103.02 74.3,103.12 74.3,103.46 74.19,103.57 73.95,103.57 73.56,103.17 73.32,103.17 U67.AF5
N17981727: length 5.1
  TOP w0.114: RZ52.1 75.02,100.9 74.71,100.9 74.14,101.47 72.87,101.47 72.24,102.1 72.24,102.34 v3(71.96,102.62)
  BOTTOM w0.114: U67.AD6 v3(71.96,102.62)
N17981744: length 5.2
  TOP w0.114: v3(72.76,102.62) 72.49,102.35 72.49,102.21 72.97,101.73 73.12,101.73 arc(73.2,101.76) 73.23,101.83 73.23,101.95 arc(73.26,102.03) 73.34,102.06 73.49,102.06 arc(73.57,102.03) 73.6,101.95 73.6,101.83 arc(73.63,101.76) 73.71,101.73 74.24,101.73 74.82,101.16 75.02,101.16 RZ50.1
  BOTTOM w0.114: U67.AE6 v3(72.76,102.62)
N17982049: length 3.6
  BOTTOM w0.114: RZ185.1 75.02,101.41 74.21,101.41 73.79,101.83 72.77,101.83 U67.AE7
N17982065: length 3.5
  BOTTOM w0.114: U67.AF7 73.32,101.57 73.68,101.57 74.1,101.16 74.27,101.16 74.37,101.05 74.37,100.74 74.48,100.63 74.63,100.63 74.74,100.74 74.74,101.05 74.85,101.16 75.02,101.16 RZ186.1
N17982119: length 7.7
  TOP w0.114: RZ55.1 75.02,98.62 74.35,98.62 74.08,98.89 74.08,99.81 73.96,99.92 72.82,99.92 71.32,101.42 70.76,101.42 v3(70.36,101.82)
  BOTTOM w0.114: U67.AB7 v3(70.36,101.82)
N17982135: length 7.7
  TOP w0.114: v3(71.16,101.82) 71.3,101.68 71.42,101.68 72.92,100.18 73.17,100.18 arc(73.25,100.21) 73.28,100.29 73.28,100.56 arc(73.33,100.67) 73.44,100.72 73.49,100.72 arc(73.6,100.67) 73.65,100.56 73.65,100.29 arc(73.68,100.21) 73.76,100.18 74.07,100.18 74.33,99.91 74.33,99 74.46,98.87 75.02,98.87 RZ54.1
  BOTTOM w0.114: U67.AC7 v3(71.16,101.82)
N17983399: length 10.4
  TOP w0.114: CM33.1 54.48,111.71 54.48,107.67 55.37,106.78 55.37,105.79 56.13,105.03 56.97,105.03 57.29,104.71 57.29,104.49 v3(57.56,104.22)
  BOTTOM w0.114: U67.G4 v3(57.56,104.22)
N17983402: length 10.4
  TOP w0.114: CM32.1 54.23,111.71 54.23,107.57 55.12,106.68 55.12,105.69 56.03,104.78 56.87,104.78 57.03,104.61 57.03,104.49 v3(56.76,104.22)
  BOTTOM w0.114: U67.F4 v3(56.76,104.22)
N17983405: length 4.2
  TOP w0.114: v3(57.56,105.82) 57.29,106.09 57.29,106.31 55.75,107.85 55.75,108.2 56.13,108.58
  BOTTOM w0.114: U67.G2 v3(57.56,105.82)
N17983408: length 4.2
  TOP w0.114: v3(56.76,105.82) 57.03,106.09 57.03,106.21 55.5,107.74 55.5,108.2 55.12,108.58
  BOTTOM w0.114: U67.F2 v3(56.76,105.82)
N17983588: length 3.2
  BOTTOM w0.114: U67.H1 58.92,106.22 59.03,106.33 59.03,106.54 57.91,107.66 57.91,108.24 CM69.1
N17983600: length 3.2
  BOTTOM w0.114: U67.J1 59.4,106.22 59.29,106.33 59.29,106.65 58.17,107.77 58.17,108.24 CM68.1
N17983612: length 8.8
  TOP w0.114: v3(58.36,105.02) 58.62,105.28 58.62,105.49 58.75,105.61 58.75,106.2 56.95,108 56.95,110.82 56.71,111.06 56.71,111.71 CM34.1
  BOTTOM w0.114: U67.H3 v3(58.36,105.02)
N17983616: length 8.8
  TOP w0.114: CM35.1 56.96,111.71 56.96,111.16 57.2,110.92 57.2,108.11 59,106.3 59,105.51 58.88,105.38 58.88,105.3 v3(59.16,105.02)
  BOTTOM w0.114: U67.J3 v3(59.16,105.02)
N17983696: length 3.5
  TOP w0.114: v3(59.96,105.82) 60.1,105.95 60.1,106.9 60.31,107.12 60.31,108.09 CM42.1
  BOTTOM w0.114: U67.K2 v3(59.96,105.82)
N17983708: length 3.6
  TOP w0.114: v3(60.76,105.82) 60.35,106.23 60.35,106.8 60.57,107.01 60.57,108.06 CM43.1
  BOTTOM w0.114: U67.L2 v3(60.76,105.82)
N17983720: length 9.1
  TOP w0.114: v3(59.96,104.22) 60.2,104.46 60.2,104.64 59.31,105.53 59.31,106.78 59.12,106.97 59.12,111.71 CM36.1
  BOTTOM w0.114: U67.K4 v3(59.96,104.22)
N17983724: length 9.2
  TOP w0.114: v3(60.76,104.22) 60.45,104.53 60.45,104.75 59.56,105.64 59.56,106.89 59.37,107.08 59.37,111.71 CM37.1
  BOTTOM w0.114: U67.L4 v3(60.76,104.22)
N17983804: length 2.8
  BOTTOM w0.114: U67.M1 62.23,106.49 62.23,107.04 62.74,107.55 62.74,108.2 62.36,108.58
N17983816: length 2.8
  BOTTOM w0.114: U67.N1 62.48,106.49 62.48,106.93 62.99,107.44 62.99,108.2 63.37,108.58
N17983828: length 8.1
  TOP w0.114: v3(61.56,105.02) 61.71,105.02 61.85,105.16 61.85,105.32 61.59,105.57 61.59,111.71 CM38.1
  BOTTOM w0.114: U67.M3 v3(61.56,105.02)
N17983832: length 8.1
  TOP w0.114: v3(62.36,105.02) 62.24,105.02 62.1,105.16 62.1,105.42 61.85,105.68 61.85,111.71 CM39.1
  BOTTOM w0.114: U67.N3 v3(62.36,105.02)
N17985522: length 1.7
  BOTTOM w0.114: U41.21 22.81,37.84 22.69,37.97 22.69,38.53 CM81.1
N17985526: length 1.7
  BOTTOM w0.114: CM82.1 22.43,38.51 22.43,37.95 22.31,37.83 U41.20
N17985638: length 1.9
  BOTTOM w0.114: U43.21 39.58,34.93 39.45,35.05 39.45,35.86 CM93.1
N17985642: length 1.9
  BOTTOM w0.114: CM94.1 39.2,35.85 39.2,35.02 39.08,34.9 U43.20
N17985774: length 1.9
  BOTTOM w0.114: CM91.1 57.74,35.86 57.74,35.05 57.86,34.93 U45.21
N17985778: length 1.9
  BOTTOM w0.114: CM92.1 57.49,35.85 57.49,35.02 57.36,34.9 U45.20
N17985910: length 1.9
  BOTTOM w0.114: U47.21 76.15,35.05 76.03,35.17 76.03,35.86 CM89.1
N17985914: length 1.9
  BOTTOM w0.114: CM90.1 75.77,35.85 75.77,35.17 75.65,35.05 U47.20
N17986046: length 1.9
  BOTTOM w0.114: CM87.1 94.32,35.86 94.32,35.05 94.44,34.93 U49.21
N17986050: length 1.9
  BOTTOM w0.114: CM88.1 94.06,35.85 94.06,35.02 93.94,34.9 U49.20
N17986184: length 1.9
  BOTTOM w0.114: CM85.1 112.6,35.86 112.6,35.05 112.73,34.93 U51.21
N17986188: length 1.9
  BOTTOM w0.114: CM86.1 112.35,35.85 112.35,35.02 112.23,34.9 U51.20
N17986320: length 1.9
  BOTTOM w0.114: CM83.1 130.89,36.24 130.89,35.43 131.02,35.31 U53.21
N17986324: length 1.9
  BOTTOM w0.114: CM84.1 130.64,36.23 130.64,35.4 130.52,35.28 U53.20
N17986454: length 1.7
  BOTTOM w0.114: U55.21 126.11,47.07 125.98,46.95 125.69,46.95 125.58,46.83 125.42,46.83 CM79.1
N17986458: length 1.7
  BOTTOM w0.114: U55.20 126.14,46.57 126.01,46.69 125.8,46.69 125.68,46.58 125.46,46.58 CM80.1
N17989951: length 4.5
  TOP w0.254: R659.2 40.32,104.67 41.1,103.9 U73.1
  TOP w0.508: R659.2 38.82,104.67 C385.2 38.79,104.74 R655.1
N17989959: length 3
  TOP w0.254: U73.4 41,102.55 40.89,102.44 RB33.2 RZU25.2
N17990621: length 3
  TOP w0.254: U72.4 40.04,92.89 RB41.2 RZU27.2
N17990625: length 4.5
  TOP w0.254: R654.2 40.32,95.02 41.1,94.24 U72.1
  TOP w0.508: C380.2 38.77,95.08 R651.1 38.84,95.02 R654.2
N18023847: length 1.6
  TOP w0.254: Q11.D 116.38,69.34 RZ78.1
N18024364: length 1.4
  TOP w0.107: Q14.D 120.19,74.68 120.55,74.32 RZ72.1
N18025778: length 1.5
  TOP w0.254: U80.5 94.35,99.68 94.69,99.34 R714.1
N18025836: length 1.3
  TOP w0.254: RZ56.2 93.5,101.93 U80.8
N18025865: length 1.6
  TOP w0.254: C434.1 94.51,102.04 94.51,101.09 94.1,100.68 U80.7
N18053287: length 1.4
  BOTTOM w0.254: U32.5 141.47,177.66 141.83,178.03 R226.1
N18053364: length 1.5
  BOTTOM w0.107: C130.1 141.52,175.79 141.28,176.02 U32.7
N18054826: length 4.1
  BOTTOM w0.254: U79.1 87.62,93.54 R713.2
  BOTTOM w0.508: R713.2 C427.2 88.81,92.16 R706.1
N18054834: length 2.6
  TOP w0.254: RB35.2 86.68,91.97 v1(86.89,92.19) 86.93,92.23 RZU26.2
  BOTTOM w0.254: U79.4 v1(86.89,92.19)
N18055461: length 3.9
  TOP w0.203: 132.51,176.68 U34.10
  TOP w0.254: 132.51,176.68 133.61,176.68 R247.2 R246.1
N18068175: length 5.5
  BOTTOM w0.107: JPPCIE1.1 34.32,85.24 Q29.G 37.29,86.69 RZ194.1
N18076130: length 2.2
  BOTTOM w0.203: R288.1 29.62,39.85 30.21,39.26 LANLINK1.C1
N18076153: length 3
  BOTTOM w0.254: LANLINK1.C2 31.26,37.96 32.13,37.08 32.77,37.08 33.05,36.8 R289.1
N18076291: length 3.9
  BOTTOM w0.305: LANACT1.C 28.6,40.79 27.81,40.01 R286.1
