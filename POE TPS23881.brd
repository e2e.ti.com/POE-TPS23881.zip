# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18076865: length 1.7
  BOTTOM w0.305: R310.1 43.8,37.71 LANACT2.C
N18076892: length 1.5
  BOTTOM w0.203: LANLINK2.C1 46.46,36.93 R312.1
N18076913: length 1.8
  BOTTOM w0.203: R313.1 48.23,36.37 LANLINK2.C2
N18077498: length 1.7
  BOTTOM w0.305: LANACT3.C 62.09,37.71 R333.1
N18077525: length 1.5
  BOTTOM w0.203: LANLINK3.C1 64.75,36.93 R336.1
N18077546: length 1.8
  BOTTOM w0.203: R337.1 66.52,36.37 LANLINK3.C2
N18078897: length 1.7
  BOTTOM w0.305: R356.1 80.38,37.71 LANACT4.C
N18078924: length 1.5
  BOTTOM w0.203: R360.1 83.03,36.93 LANLINK4.C1
N18078945: length 1.8
  BOTTOM w0.203: LANLINK4.C2 84.81,36.37 R361.1
N18079699: length 1.7
  BOTTOM w0.305: R381.1 98.67,37.71 LANACT5.C
N18079726: length 2.1
  BOTTOM w0.203: LANLINK5.C1 101.55,36.93 R384.1
N18079747: length 1.7
  BOTTOM w0.203: LANLINK5.C2 103.62,35.68 103.1,35.15 R385.1
N18080540: length 1.7
  BOTTOM w0.305: LANACT6.C 116.95,37.71 R405.1
N18080567: length 1.5
  BOTTOM w0.203: R408.1 119.41,36.93 119.92,36.41 LANLINK6.C1
N18080588: length 1.8
  BOTTOM w0.203: R409.1 121.39,36.37 LANLINK6.C2
N18081372: length 1.7
  BOTTOM w0.305: LANACT7.C 135.24,38.09 R429.1
N18081399: length 1.5
  BOTTOM w0.203: R432.1 137.9,37.31 LANLINK7.C1
N18081420: length 1.8
  BOTTOM w0.203: LANLINK7.C2 139.67,36.76 R433.1
N18082215: length 2.4
  BOTTOM w0.254: R454.1 125.35,56.87 125.48,57 LANACT8.C
N18082242: length 2.4
  BOTTOM w0.203: R456.1 126.44,56.85 127.11,57.52 LANLINK8.C1
N18082263: length 1.6
  BOTTOM w0.203: LANLINK8.C2 128.41,57.28 128.65,57.04 128.65,56.52
N18092346: length 1.6
  TOP w0.107: J1.K40 87.72,131.44 v1(87.72,132.02)
  BOTTOM w0.107: TP1.1 87.27,132.53 87.72,132.08 v1(87.72,132.02)
N18120066: length 6.3
  BOTTOM w0.508: 51.64,178.69 52.53,179.58 56.39,179.58 56.77,179.2 R260.1
N18165594: length 1.5
  TOP w0.254: U81.5 99.97,95.61 100.3,95.28 R715.1
N18165656: length 1.3
  TOP w0.254: RZ57.2 U81.8
N18165690: length 2.2
  TOP w0.254: U81.7 99.77,96.66 99.77,97.13 99.97,97.33 101.23,97.33 C432.1
N18173925: length 1.8
  TOP w0.107: U13.3 v1(142.25,67.3)
  BOTTOM w0.107: v1(142.25,67.3) 142.24,67.31 RZ204.2
N18173928: length 1.9
  TOP w0.107: U13.14 142.37,72.8 v1(142.27,72.9)
  BOTTOM w0.107: RZ201.2 141.83,72.9 v1(142.27,72.9)
N18186882: length 4.3
  TOP w0.107: RZU22.1 145,109.8 145.57,110.36 146.71,110.36 147.31,110.96 SSD2.40
N18186907: length 3.7
  TOP w0.107: RZU23.1 146.14,109.67 146.33,109.86 146.79,109.86 147.81,110.88 SSD2.42
N18187137: length 3.6
  TOP w0.254: SSD2.69 154.56,119.25 153.92,119.89 153.16,119.89 152.78,120.27 RZ23.2
N18187139: length 11.5
  TOP w0.107: SSD2.68 154.31,111.12 154.56,110.87 155.22,110.87 157.1,108.99 R761.2
N18187141: length 2.1
  TOP w0.107: R761.1 155.27,100.99 U84.3
N18187143: length 5.2
  TOP w0.381: U84.1 153.16,99.36 FB39.1 151.52,99.38 CA65.1 152.61,100.91 U84.4
N18192110: length 1.5
  BOTTOM w0.203: U85.12 140.97,101.6 R763.2
N18192155: length 2.1
  BOTTOM w0.107: U85.2 139.78,103.36 RZ35.2
N18192178: length 1.8
  BOTTOM w0.107: RZ38.2 139.04,103.76 U85.3
N18192205: length 1.8
  BOTTOM w0.107: RZ40.2 139.02,104.16 U85.4
N18192224: length 2.1
  BOTTOM w0.107: U85.5 139.76,104.56 RZ46.2
N18194663: length 1.6
  TOP w0.254: U18.1 108.32,81.64 RZ61.2
N18194685: length 1.8
  TOP w0.254: U18.14 v1(113.44,86.51)
  BOTTOM w0.254: v1(113.44,86.51) 113.39,86.46 RZ192.2
N18194768: length 2.1
  TOP w0.107: U18.19 110.82,89.28 110.24,89.87 R1484.2
N18194804: length 2
  TOP w0.107: U18.24 108.32,88.58 107.95,88.95 R1485.2
N18194817: length 2.1
  TOP w0.107: U18.21 109.82,89.34 R1486.2
N18194942: length 1.8
  TOP w0.254: R769.2 110.82,81.97 U18.6
N18195475: length 1.6
  TOP w0.203: RB38.2 110.54,97.82 110.07,97.35 U86.5
N18195479: length 2.5
  TOP w0.203: 111.04,95.01 110.9,95.16 U86.1 110.07,95.03 U86.16
  TOP w0.254: 111.04,95.01 111.17,94.89 111.17,94.5 RB39.2
N18195489: length 1.8
  TOP w0.203: v1(111.02,96.52) 110.73,96.52 110.57,96.36 U86.4
  BOTTOM w0.381: 110.11,96.52 v1(111.02,96.52)
N18196140: length 3.1
  BOTTOM w0.254: Q51.2 111.28,93.62 RB36.1 111.63,93.75 111.93,93.46 Q51.3
N18233097: length 2.3
  TOP w0.508: RZ1.2 v1(14.35,195.58)
  BOTTOM w0.508: Q15.B 14.33,195.61 v1(14.35,195.58)
N18237049: length 2
  BOTTOM w0.102: RZ176.2 132.86,122.04 132.86,122.56 132.74,122.68 WIFI1.3
N18237080: length 1.9
  BOTTOM w0.102: WIFI1.5 133.24,122.7 133.11,122.57 133.11,122 RZ175.2
N18237082: length 5.7
  BOTTOM w0.203: WIFI1.6 133.49,130 133.28,129.79 132.35,129.79 132.02,130.13 130.37,130.13 130.16,129.92 LED1.C
N18237084: length 1.5
  BOTTOM w0.254: R188.2 127.24,130.18 LED1.A
N18237134: length 4.3
  TOP w0.107: RZU18.2 v1(133.48,125.86)
  BOTTOM w0.107: v1(133.48,125.86) 133.6,125.86 134.24,125.22 WIFI1.9
N18237158: length 5.4
  TOP w0.107: RZU13.2 132.56,126.36 133.86,126.36 v1(134.37,125.86)
  BOTTOM w0.107: v1(134.37,125.86) 134.74,125.49 WIFI1.11
N18237182: length 4
  TOP w0.107: v1(135.25,125.98) 134.37,126.87 RZU14.2
  BOTTOM w0.107: v1(135.25,125.98) 135.24,125.97 WIFI1.13
N18237217: length 3.8
  TOP w0.107: RZU15.2 136.4,126.59 v1(136.4,125.98)
  BOTTOM w0.107: v1(136.4,125.98) 135.74,125.32 WIFI1.15
N18237219: length 8.8
  BOTTOM w0.203: WIFI1.16 135.99,132.29 135.56,132.72 131.83,132.72 130.94,131.83 LED2.C
N18237221: length 1.4
  BOTTOM w0.254: R189.2 LED2.A
N18237240: length 3.8
  TOP w0.107: RZU10.2 v1(137.54,125.98)
  BOTTOM w0.107: WIFI1.17 136.24,124.68 v1(137.54,125.98)
N18237264: length 4.2
  TOP w0.107: RZU11.2 v1(138.68,125.98)
  BOTTOM w0.107: v1(138.68,125.98) 138.43,125.98 136.74,124.29 WIFI1.19
N18237285: length 4.8
  TOP w0.107: RZU12.2 v1(139.83,125.98)
  BOTTOM w0.107: WIFI1.21 137.24,124.18 138.51,125.45 139.29,125.45 v1(139.83,125.98)
N18237289: length 5.4
  TOP w0.107: RZU17.2 v1(141,126.01)
  BOTTOM w0.107: v1(141,126.01) 140,125.02 138.71,125.02 137.74,124.05 WIFI1.23
N18237399: length 4.6
  BOTTOM w0.114: CM67.2 138.3,122.09 138.3,122.34 138.57,122.61 139.54,122.61 139.8,122.34 140.78,122.34 140.85,122.41 140.85,122.6 140.74,122.71 WIFI1.35
N18237422: length 4.6
  BOTTOM w0.114: CM66.2 138.56,122.09 138.56,122.24 138.67,122.35 139.43,122.35 139.7,122.09 140.89,122.09 141.1,122.3 141.1,122.6 141.24,122.74 WIFI1.37
N18237451: length 2.4
  BOTTOM w0.107: RZU42.1 141.49,133.32 WIFI1.38
N18237476: length 1.9
  BOTTOM w0.114: WIFI1.41 142.24,122.68 142.36,122.56 142.36,122.07 RZ173.2
N18237478: length 1.4
  BOTTOM w0.107: TP39.1 141.99,131.95 WIFI1.40
N18237490: length 1.9
  BOTTOM w0.114: WIFI1.43 142.74,122.67 142.61,122.55 142.61,122.08 RZ172.2
N18237492: length 2.5
  BOTTOM w0.107: WIFI1.42 142.49,131.95 142.65,132.11 RZ170.1
N18237555: length 1.8
  BOTTOM w0.107: WIFI1.53 145.24,122.17 145.16,122.1 RZ174.2
N18237567: length 6.1
  TOP w0.107: R199.1 RZU16.2 145.82,126.49 146.18,126.14 Q17.D 146.18,125.09 v1(145.67,124.59)
  BOTTOM w0.107: v1(145.67,124.59) 145.67,124.55 145.74,124.48 WIFI1.55
N18237624: length 3.7
  TOP w0.107: RZ21.2 v1(148.08,125.6)
  BOTTOM w0.107: v1(148.08,125.6) 147.7,125.6 146.81,124.71 146.81,124.33 146.74,124.26 WIFI1.59
N18237626: length 2.2
  BOTTOM w0.107: WIFI1.58 146.49,133.07 RZU41.1
N18237645: length 4.2
  TOP w0.107: RZ22.2 v1(149.22,125.6)
  BOTTOM w0.107: v1(149.22,125.6) 148.72,125.09 147.83,125.09 147.24,124.5 WIFI1.61
N18237647: length 2.4
  BOTTOM w0.107: WIFI1.60 146.99,132.53 RZU40.1
N18237667: length 3.8
  BOTTOM w0.107: RZ169.1 R195.1 147.49,131.89 WIFI1.62
N18238169: length 2.5
  TOP w0.107: U29.3 142.53,136 R194.1
N18238171: length 5.2
  TOP w0.254: U29.1 137.02,134.25 136.7,134.57 FB5.1 136.14,135.93 CA55.1 137.95,136.02 U29.4
N18239373: length 1.5
  BOTTOM w0.254: U30.5 129.4,140.47 130.15,139.73 R202.1
N18239450: length 1.4
  BOTTOM w0.254: C92.1 127.98,139.92 128.41,140.34 U30.7
N18353073: length 1.5
  BOTTOM w0.254: PLED1.A 137.02,40.74 R230.2
N18353085: length 2
  TOP w0.254: Q19.D 134.9,41.15 v1(134.26,40.51)
  BOTTOM w0.254: v1(134.26,40.51) 135.14,40.51 PLED1.C
N18355368: length 6.2
  BOTTOM w0.508: PWRBTN1.1 154.56,19.05 152.25,19.05 R677.2
N18355613: length 7.2
  BOTTOM w0.508: RESET1.1 156.28,134.17 154.69,135.76 154.69,137.67 153.8,138.56 R680.2
N18355836: length 13.5
  BOTTOM w0.508: RECOVERY1.1 154.89,122.86 153.67,124.08 153.67,132.23 R682.2
N18552806: length 2.4
  BOTTOM w0.381: RZ162.1 153.89,146.94 154.05,147.1 AUDIO1.4
N18554011: length 4.7
  BOTTOM w0.381: RZ160.2 156.35,148.08 AUDIO1.3
N18656044: length 3
  BOTTOM w0.254: U87.7 125.76,65.47 125.66,65.36 125.66,65.08 125.78,64.97 U87.8 127.45,64.97 R1334.2
N18656142: length 1.6
  TOP w0.107: v1(124.08,65.79) 124.21,65.66 RZ91.2
  BOTTOM w0.107: v1(124.08,65.79) 123.9,65.97 U87.3
N18656144: length 1.6
  BOTTOM w0.107: RZ206.1 127.89,65.97 U87.6
N18656178: length 1.6
  TOP w0.107: v1(124.08,66.55) 124.33,66.8 RZ86.2
  BOTTOM w0.107: v1(124.08,66.55) 124,66.47 U87.4
N18656180: length 1.8
  BOTTOM w0.107: RZ205.1 127.45,66.47 U87.5
N18665598: length 17
  TOP w0.508: Q63.4 v1(17.98,98.86) ; Q68.4 v1(12.65,96.09)
  IN1 w0.508: v1(12.65,96.09) 15.42,98.86 v1(17.98,98.86) 19.51,97.33 19.51,93.29 20.6,92.2 POESLT1.2
N18665787: length 14.8
  TOP w0.508: v1(6.43,95.99) Q64.4 ; Q67.4 v1(11.71,98.83)
  IN1 w0.508: POESLT2.2 4.01,92.2 4.52,92.71 4.52,94.94 5.56,95.99 v1(6.43,95.99) 8.86,95.99 v1(11.71,98.83)
N18665860: length 9
  TOP w0.254: Q69.6 3.56,80.01 3.76,80.21 3.76,83.22 3.51,83.47 Q66.5 2.15,83.47 1.97,83.65 1.97,85.03 2.24,85.29 R1507.1
N18790442: length 2.5
  TOP w0.107: U14.1 125.25,75.69 126.24,76.68 RZ67.2
N18790882: length 1.7
  TOP w0.107: RB53.1 124.45,72.45 U14.10
N18790917: length 3.4
  TOP w0.107: U14.3 124.45,75.86 123.95,76.35 RB48.1 RZU30.1
N18790923: length 2.1
  TOP w0.107: RB49.1 125.09,76.17 124.85,75.93 U14.2
N18791105: length 2.5
  TOP w0.107: U14.9 124.05,72.78 123.91,72.64 123.09,72.64 122.68,72.24 RB52.1
N18797950: length 15.1
  TOP w0.508: DC_IN1.1 16.09,177.32 ; DC_IN1.1 17.35,176.06 ; DC_IN1.1 14.83,176.06 ; DC_IN1.1 16.09,174.8
  IN3 w0.762: 14.83,176.06 DC_IN1.1 ; DC_IN1.1 16.09,174.8 ; DC_IN1.1 17.35,176.06 ; DC_IN1.1 16.09,177.32
  BOTTOM w0.508: 14.83,176.06 DC_IN1.1 ; DC_IN1.1 16.09,174.8 ; DC_IN1.1 16.09,177.32 ; DC_IN1.1 17.35,176.06
  vias: v2(16.13,180.85) v2(16.13,179.96) v2(16.13,179.07) v2(17.02,180.85) v2(17.02,179.96) v2(17.02,179.07) v2(17.91,180.85) v2(17.91,179.96) v2(17.91,179.07) v2(17.91,178.05) v2(17.91,177.16) v2(17.91,176.28) v2(17.91,175.39) v2(17.91,174.5) v2(17.91,173.61) v2(18.8,178.05) v2(18.8,177.16) v2(18.8,176.28) v2(18.8,175.39) v2(18.8,174.5) v2(18.8,173.61) v2(19.68,178.05) v2(19.68,177.16) v2(19.68,176.28) v2(19.68,175.39) v2(19.68,174.5) v2(19.68,173.61)
N18798062: length 2
  BOTTOM w0.508: U74.5 20.85,177.72 Q30.4
N18798173: length 2.7
  BOTTOM w0.508: C392.2 19.63,184.55 19.63,183.09 19.9,182.81 U74.1
N18798292: length 5.5
  TOP w0.381: Q31.4 63.63,156.92 64.01,156.54 R667.1
  TOP w0.508: R664.2 66.67,158.14 C394.2 65.63,158.04 R667.1
N18798370: length 4
  TOP w0.508: R670.1 R671.1 65.74,152.86 Q32.D
N18798998: length 2.8
  TOP w0.381: U75.1 56.12,167.5 55.85,167.23 R665.1
  TOP w0.508: R665.1 R663.2
N18799362: length 1.8
  TOP w0.508: FB38.2 R662.1
N18799364:
  vias: v2(1.91,178.82) v2(1.91,178.05) v2(2.79,178.82) v2(2.79,178.05) v2(3.68,178.82) v2(3.68,178.05)
N18880064: length 1.6
  TOP w0.254: RZ73.1 116.23,72.09 Q13.D
N18880909: length 2.4
  TOP w0.254: Q19.G 137.23,40.67 R1509.1 RZ120.2
N18881934: length 23.9
  IN1 w0.508: v1(147.32,152.3) 147.32,145.16 146.43,144.27 146.43,141.35 145.41,140.34 138.94,140.34 138.3,140.97 138.3,141.35 137.54,142.11 v1(137.54,142.88)
  BOTTOM w0.203: v1(137.54,142.88) 137.65,142.98 U16.26
  BOTTOM w0.508: RZ685.1 v1(147.32,152.3)
N18881943: length 23.1
  IN1 w0.508: v1(137.54,143.89) 137.74,143.89 138.25,143.38 138.25,142.67 139.06,141.86 143.64,141.86 144.32,142.54 144.32,145.16 146.46,147.29 146.46,153.59 v1(147.32,154.46)
  BOTTOM w0.203: v1(137.54,143.89) 137.65,143.78 U16.28
  BOTTOM w0.508: RZ686.1 v1(147.32,154.46)
N18882012: length 8.1
  BOTTOM w0.381: AUDIO1.7 156.34,152.1 153.87,152.1 153.67,151.89 RZ153.2 153.01,152.15 152.63,152.53 150.98,152.53 150.47,152.02 RZU37.2
N18882124: length 5.7
  BOTTOM w0.381: RZU39.1 150.47,150.55 150.85,150.16 152.63,150.16 153.01,150.55 RZ154.2 153.54,150.75 153.89,151.1 AUDIO1.8
N18931604: length 2
  TOP w0.229: R173.2 79.53,151.03 80.08,151.58 U25.34
N19048317: length 8.1
  BOTTOM w0.203: 146.05,145.45 145.88,145.62 145.28,145.62 145.04,145.38 U16.5
  BOTTOM w0.381: C898.2 151.71,145.45 146.05,145.45
N19048952: length 8
  BOTTOM w0.203: 146.05,144.78 145.73,144.78 145.6,144.65 145.23,144.65 145.16,144.58 U16.7
  BOTTOM w0.381: 146.05,144.78 146.18,144.91 151.8,144.91 C899.2
N19126579: length 2.1
  BOTTOM w0.508: C917.1 11.07,122.68 11.43,123.04 R1510.2
N19200612: length 3.3
  BOTTOM w0.107: RB62.1 RZ688.2 66.8,177.93 66.93,178.05 U38.1
N19201084: length 2
  TOP w0.107: R1511.2 64.38,177.02 U36.2
N20328471: length 3.2
  TOP w0.107: SPI2.2 v1(52.27,46.94)
  BOTTOM w0.107: RZ114.2 R644.2 v1(52.27,46.94)
N20328520: length 6
  TOP w0.107: v1(49.23,48.34) 49.1,48.21 SPI2.6
  BOTTOM w0.107: RZ111.1 48.72,50.34 48.72,48.84 v1(49.23,48.34)
N20328523: length 3.2
  TOP w0.107: SPI2.5 v1(49.23,49.48)
  BOTTOM w0.107: RZ110.1 49.86,50.5 49.23,49.86 v1(49.23,49.48)
N20328554: length 1.9
  TOP w0.107: R645.2 SPI2.7
N20493475: length 1.3
  TOP w0.107: RZ108.1 R639.1
N20493478: length 1.6
  TOP w0.254: RZ89.1 64.41,64.79 65.56,64.79 R640.1
N25237920: length 5.2
  BOTTOM w0.203: RB14.2 R285.1 32.4,29.36 C173.1 32.97,28.79 32.97,28.3 33.4,27.86 33.4,26.45 33.2,26.25 X2.3
N53913115: length 3.1
  TOP w0.107: RZ68.2 R607.2 SPI1.2
N53913461: length 3.9
  TOP w0.107: v1(67.34,78.49) SPI1.6
  BOTTOM w0.107: RZ65.1 66.07,78.71 66.29,78.49 v1(67.34,78.49)
N53913464: length 2.9
  TOP w0.107: SPI1.5 67.16,79.76 v1(67.67,79.25)
  BOTTOM w0.107: v1(67.67,79.25) 68.07,79.25 68.17,79.35 RZ198.1
N53913963: length 2.1
  TOP w0.254: SPI1.7 65.05,77.22 64.57,77.7 R608.2
N54184803: length 5.4
  TOP w0.114: RZ33.1 75.46,105.84 75.35,105.73 74.99,105.73 74.68,105.41 74.68,105.05 74.52,104.9 72.52,104.9 72.21,104.59 72.21,104.37 72.06,104.22 v3(71.96,104.22)
  BOTTOM w0.114: U67.AD4 v3(71.96,104.22)
N54186028: length 5.5
  TOP w0.114: RZ37.1 75.46,105.36 75.35,105.47 75.1,105.47 74.93,105.3 74.93,104.95 74.63,104.65 74.51,104.65 arc(74.43,104.61) 74.4,104.54 74.4,104.45 arc(74.36,104.34) 74.24,104.29 74.18,104.29 arc(74.08,104.34) 74.03,104.44 arc(73.97,104.59) 73.83,104.65 72.63,104.65 72.47,104.48 72.47,104.34 72.59,104.22 v3(72.76,104.22)
  BOTTOM w0.114: U67.AE4 v3(72.76,104.22)
N54369784: length 2.8
  BOTTOM w0.114: RZ179.1 75.02,106.24 73.75,106.24 73.45,105.94 73.28,105.94 73.16,106.06 U67.AF1
N54371660: length 2.8
  BOTTOM w0.114: RZ181.1 75.02,105.98 73.85,105.98 73.56,105.69 73.28,105.69 73.16,105.58 U67.AF2
N54465881: length 7
  TOP w0.114: v3(69.56,102.62) 69.95,103.01 70.62,103.01 71.04,103.42 75,103.42 RZ42.1
  BOTTOM w0.114: U67.AA6 v3(69.56,102.62)
N54465893: length 7
  TOP w0.114: RZ48.1 75.04,103.17 74.78,103.17 arc(74.66,103.12) 74.61,103 74.61,102.71 arc(74.56,102.58) 74.44,102.53 arc(74.3,102.58) 74.25,102.72 74.25,102.97 arc(74.19,103.11) 74.05,103.17 71.14,103.17 70.73,102.75 70.49,102.75 v3(70.36,102.62)
  BOTTOM w0.114: U67.AB6 v3(70.36,102.62)
N59689924: length 2
  TOP w0.813: C254.1 87.1,8.33 R472.2
N59689926: length 1.9
  TOP w0.813: R473.2 83.16,8.26 C255.1
N59689928: length 1.9
  TOP w0.813: R474.2 C256.1
N59689930: length 1.9
  TOP w0.813: R475.2 C257.1
N59691945: length 2
  TOP w0.813: C249.1 66.9,8.33 R468.2
N59691947: length 1.9
  TOP w0.813: R469.2 62.97,8.26 C250.1
N59691949: length 2
  TOP w0.813: R470.2 59.03,8.31 C251.1
N59691951: length 0.1
  TOP w0.813: 55.09,10.29 C252.1
N59697516: length 2
  TOP w0.813: C238.1 24.94,8.2 R460.2
N59697518: length 2
  TOP w0.813: C240.1 20.88,8.2 R461.2
N59697520: length 2
  TOP w0.813: R462.2 16.81,8.2 C241.1
N59697522: length 2
  TOP w0.813: R463.2 12.75,8.33 C242.1
N59698213: length 0.1
  TOP w0.762: 42.77,10.29 C245.1
N60625316: length 1.8
  TOP w0.102: CA75.2 100.16,65.28 100.76,65.28 101.03,65 L6.4
N60625341: length 1.8
  TOP w0.102: CA74.2 100.16,65.53 100.76,65.53 101.03,65.81 L6.1
N63435656: length 3.3
  TOP w0.254: U22.5 96.85,59.89 97.1,59.64 97.1,58.14 R170.2
N63437012: length 4
  BOTTOM w0.254: U23.5 81.1,52.27 81.36,52.53 81.36,53.29 81.74,53.67 82.78,53.67 R171.2
N63438290: length 1.7
  TOP w0.102: CA79.2 83.19,56.76 83.19,56.18 82.91,55.91 L5.4
N63438309: length 1.7
  TOP w0.102: CA78.2 83.44,56.76 83.44,56.21 83.71,55.94 L5.1
N66390376: length 1.7
  BOTTOM w0.107: TP40.1 156.82,175.67 NGFF1.1
N66390584: length 1.7
  BOTTOM w0.107: NGFF1.21 156.79,180.67 TP41.1
N66390616: length 3.3
  BOTTOM w0.107: NGFF1.25 156.02,181.67 156.59,181.1 157.48,181.1 TP42.1
N66390835: length 2.1
  BOTTOM w0.107: TP43.1 156.86,192.67 NGFF1.69
N66390837: length 2.4
  BOTTOM w0.107: TP44.1 147.18,192.42 NGFF1.68
N66390898: length 2.1
  BOTTOM w0.107: TP45.1 156.97,194.31 156.08,194.31 155.94,194.17 NGFF1.75
N100957080: length 2
  TOP w0.107: U42.3 17.15,39.37 17.15,39.75 16.89,40.01 RA16.1
N101129395: length 1.4
  TOP w0.107: U42.7 17.65,35.25 RA23.1
N198711181: length 2.8
  BOTTOM w0.254: 142.77,97.28 142.77,96.9 142.91,96.77 U77.8
  BOTTOM w0.508: R695.2 142.52,98.04 142.77,97.79 142.77,97.28
N198711183: length 1.3
  BOTTOM w0.508: R695.1 142.49,100.08 CM72.1
N209543093: length 2.7
  BOTTOM w0.254: U77.11 144.39,98.27 144.81,98.68 R698.2 R697.1
N209574440: length 2.8
  TOP w0.381: v1(143.39,94.11) 143.15,94.35 R699.1 R700.2
  BOTTOM w0.254: U77.6 v1(143.39,94.11)
N236903799: length 2.3
  BOTTOM w0.203: 133.06,87.31 133.25,87.12 133.48,87.12 133.68,86.92 U76.1
  BOTTOM w0.381: 133.06,87.31 132.46,87.91 RZ189.2
N236903801: length 2.1
  BOTTOM w0.508: RZ189.1 131.5,87.73 132.11,87.12 C395.1
N236903803: length 1.5
  TOP w0.508: v1(139.6,87.63) 139.6,88.87 R684.2
  vias: v1(136.17,85.09) v1(136.8,85.09) v1(137.44,85.09) v1(139.6,87) v1(139.6,84.84) v1(140.23,87.63) v1(140.23,87) v1(140.23,84.84) v1(140.87,87.63) v1(140.87,87) v1(140.87,84.84) v1(141.5,87.63) v1(141.5,87) v1(141.5,84.84) v1(142.14,87.63) v1(142.77,87.63) v1(143.41,87.63) v1(144.04,87.63)
N236903827: length 4.3
  BOTTOM w0.203: 136.42,87.76 136.42,87.5 136.18,87.26 U76.7
  BOTTOM w0.254: 136.42,87.76 136.42,88.16 R689.2
  BOTTOM w0.508: R689.2 136.64,88.4 C400.1 136.65,89.67 R686.2
N236903834: length 1.2
  BOTTOM w0.508: 138.81,89.66 CA147.1
N236903849: length 4
  TOP w0.381: RZ58.2 136.14,89.48 v1(135.69,89.03) 136.13,88.58 CA66.1
  BOTTOM w0.203: 135.84,87.88 135.84,87.44 135.78,87.38 U76.6
  BOTTOM w0.305: 135.84,87.88 135.84,88.24 R689.1 v1(135.69,89.03)
N236903854: length 10.4
  TOP w0.508: v1(133.38,83.19) 133.54,83.35 C406.1 133.54,85.6 134.05,86.11 136.14,86.11 136.65,86.61 R690.2 137.31,87 138.07,87.76 v1(138.81,87.76)
  BOTTOM w0.305: v1(133.38,83.19) 133.38,83.19 133.68,83.49 U76.19 ; 138.81,88.39 v1(138.81,87.76)
N236903856: length 2.9
  TOP w0.381: C405.1 CA66.2 135.38,88.2 v1(135.38,87.66)
  BOTTOM w0.203: U76.5 v1(135.38,87.66)
N236903864: length 3
  TOP w0.381: v1(134.8,87.66) 134.49,87.35 R691.2
  TOP w0.508: R690.1 R691.2
  BOTTOM w0.203: v1(134.8,87.66) 134.8,87.57 134.98,87.38 U76.4
N236903867: length 1.9
  BOTTOM w0.203: U76.3 134.58,87.19 134.26,87.5 134.26,88.16 R692.2

## Copper pours and planes (outline as drawn)
3.3VCC on IN1: 78.44,157.81 86.18,157.81 86.44,157.56 86.44,153.62 86.18,153.37 81.03,153.37 80.82,153.16 80.82,148.34 80.52,148.03 78.18,148.03 77.93,148.29 77.93,157.3
5V_HDMI2 on TOP: 103.58,47.96 103.45,48.08 103.45,49.99 103.58,50.11 105.87,50.11 106.1,50.34 106.1,51.23 106.18,51.32 106.45,51.32 106.76,51.01 106.76,50.54 107.67,49.63 107.98,49.63 108.1,49.5 108.1,48.08 107.98,47.96
5V_SPKVDD on TOP: 145.29,149.1 145.29,147.32 144.65,146.69 144.27,146.69 144.15,146.81 144.15,151.49 144.68,152.02 145.54,152.02 145.67,151.89 145.67,149.48
+V1.2S on TOP: 100.2,95.94 99.29,95.94 99.24,95.99 99.24,96.24 99.26,96.27 100.1,96.27 100.56,96.72 102.29,96.72 102.39,96.62 102.39,95.71 102.26,95.58 101.75,95.58 101.56,95.77 100.37,95.77
+V1.2S on BOTTOM: 101.24,80.64 101.24,79.63 101.12,79.5 95.78,79.5 95.66,79.63 95.66,80.54 95.75,80.63 97.98,80.63 98.12,80.77 101.12,80.77
+V1.2S on BOTTOM: 99.97,97.16 102.39,97.16 103.91,95.63 103.91,89.66 103.15,88.9 103.15,88.39 103.02,88.27 102.01,88.27 101.88,88.39 101.88,91.44 99.85,93.47 99.85,97.03
+V1.2S on IN3: 102.64,90.3 104.04,90.3 104.17,90.17 104.17,80.39 103.28,79.5 100.61,79.5 100.36,79.76 100.36,82.55 101.24,83.44 101.24,88.9
+V1.2SB on TOP (solid shape): 86,90.55 86,89.15 85.75,88.9 83.72,88.9 83.59,89.03 83.59,90.55 83.72,90.68 85.88,90.68
+V1.2SB on BOTTOM (solid shape): 86.26,91.69 86.26,91.6 86.09,91.42 86.03,91.19 86.09,90.95 86.26,90.78 86.26,89.15 85.75,88.65 83.72,88.65 83.59,88.77 83.59,91.69 83.72,91.82 86.13,91.82
+V1.2SB on TOP: 98.98,95.94 98.12,95.94 97.68,95.49 96.94,95.49 96.85,95.58 96.85,96.44 96.98,96.57 97.36,96.57 97.37,96.56 97.98,96.56 98.27,96.27 99.03,96.27 99.06,96.24 99.06,96.01
+V1.2SB on IN2: 95.5,96.65 97.79,96.65 100.84,93.6 100.84,91.44 100.2,90.81 93.09,90.81 92.33,90.04 87.25,90.04 86.11,88.9 84.71,88.9 84.58,89.03 84.58,91.82 86.61,93.85 89.03,93.85 89.53,93.34 92.71,93.34 93.22,93.85 93.98,93.85 95.25,95.12 95.25,96.39
+V1.05S on TOP: 45.42,98.45 45.42,99.52 44.91,100.03 44.91,101.93 44.65,102.18 41.86,102.18 41.73,102.06 41.73,98.5 41.86,98.37 45.34,98.37
+V1.05S on BOTTOM: 41.86,100.91 44.4,100.91 44.53,100.79 44.53,98.25 44.4,98.12 41.86,98.12 41.73,98.25 41.73,100.79
+V1.8S on TOP: 135.13,149.35 137.29,149.35 137.41,149.22 137.41,145.67 136.02,144.27 136.02,144.25 135.97,144.2 135.97,143 135.71,142.75 134.16,142.75 133.99,142.93 133.99,144.12 134.26,144.4 134.26,146.71 135,147.45 135,149.22
+V1.8S on TOP: 95.78,100 93.62,100 93.57,100.05 93.57,100.3 93.6,100.33 94.44,100.33 94.89,100.79 94.89,101.22 95.02,101.35 96.8,101.35 97.94,100.2 104.04,100.2 104.55,99.69 104.55,99.19 104.29,98.93 96.8,98.93 96.16,99.57 96.16,99.62
+V1.8S on TOP: 118.62,127.76 128.4,127.76 128.65,127.51 128.65,124.97 125.86,122.17 124.08,122.17 123.95,122.3 123.95,123.57 123.57,123.95 118.24,123.95 117.47,124.71 117.47,126.62
+V1.8S on BOTTOM: 127.95,148.02 131.6,144.37 135.18,144.37 135.33,144.22 135.33,142.65 135.18,142.49 130.53,142.49 128.88,144.15 123.7,144.15 123.32,144.53 123.32,147.89 123.44,148.02
+V1.8S on IN1: 124.17,181.14 128.27,177.04 128.27,170.94 126.36,169.04 123.19,169.04 116.08,176.15 88.77,176.15 82.8,170.18 63.4,170.18 60.91,172.67 60.91,178.77 62.36,180.21 102.36,180.21 103.29,181.14
+V1.8S on IN2: 52.6,114.3 62.51,114.3 62.64,114.43 103.91,114.43 105.69,112.65 105.69,110.11 105.18,109.6 103.4,109.6 101.63,111.38 75.46,111.38 73.56,113.28 63.91,113.28 63.02,112.39 52.98,112.39 52.22,113.16 52.22,113.92
+V1.8S on IN3: 154.28,141.4 154.74,140.94 154.74,122.71 154.2,122.17 135.81,122.17 134.85,123.14 134.85,125.96 131.72,129.08 131.72,131.42 129.67,133.48 129.67,150.11 132.79,153.24 143.81,153.24 144.07,152.98 144.07,151.1 143.69,150.72 139.9,150.72 138.71,151.92 137.46,151.92 135.31,149.76 135.31,138.13 137.34,136.09 145.47,136.09 145.95,135.61 145.95,134.57 146.13,134.39 147.83,134.39 148.08,134.65 148.08,138.33 151.16,141.4
+V1.8S on IN3: 121.41,162.69 121.41,173.48 121.03,173.86 119.13,173.86 119,173.99 119,175.64 119.25,175.9 123.19,175.9 128.14,170.94 128.14,161.54 124.97,158.37 124.97,133.86 122.81,131.7 122.81,126.11 119.33,122.63 118.03,122.63 117.83,122.43 117.83,121.13 117.2,120.5 117.2,116.61 116.66,116.08 114.5,116.08 114.15,115.72 114.15,104.6 112.17,102.62 112.17,98.31 111.51,97.65 107.84,97.65 107.47,97.28 107.47,94.49 107.59,94.36 107.59,86.49 107.21,86.11 105.31,86.11 105.05,86.36 104.93,86.36 104.93,91.57 103.15,93.34 103.15,101.09 103.16,101.1 103.16,103.95 103.91,104.7 103.91,113.31 108.76,118.16 108.76,118.8 111.14,121.17 111.14,151.27 111.38,151.51 111.38,154.56 117.22,160.4 119.13,160.4
+V1.8SB on TOP: 92.33,100.74 92.71,100.36 93.34,100.36 93.4,100.3 93.4,100.08 93.34,100.03 92.61,100.03 92.46,99.87 91.44,99.87 91.36,99.95 91.36,100.63 91.47,100.74
+V1.8SB on TOP: 88.93,100.58 89.05,100.46 89.05,98.04 88.93,97.92 86.77,97.92 86.64,98.04 86.64,100.46 86.77,100.58
+V1.8SB on BOTTOM: 89.05,98.04 88.93,97.92 86.06,97.92 85.92,98.06 85.92,100.5 86,100.58 88.93,100.58 89.05,100.46
+V1.8SB on IN1: 87.27,102.74 91.47,102.74 91.97,102.23 106.96,102.23 107.21,101.98 107.21,101.3 104.72,98.81 97.82,98.81 97.05,99.57 90.58,99.57 88.93,97.92 86.89,97.92 86.51,98.3 86.51,101.98
+V2.5S on TOP: 45.42,88.82 45.42,89.87 44.91,90.37 44.91,92.28 44.65,92.53 41.86,92.53 41.73,92.41 41.73,88.85 41.82,88.76 45.35,88.76
+V2.5S on BOTTOM: 41.86,91.26 44.4,91.26 44.53,91.14 44.53,88.6 44.4,88.47 41.86,88.47 41.73,88.6 41.73,91.14
+V3.3_WLAN on TOP: 132.97,130.94 136.32,130.94 136.83,130.43 149.2,130.43 149.4,130.23 149.4,129.29 149.53,129.16 150.5,129.16 151,129.67 151,133.73 150.5,134.24 144.53,134.24 143.38,135.38 142.24,135.38 142.11,135.25 142.11,134.37 141.1,133.35 137.16,133.35 136.53,133.99 135.76,133.99 134.26,135.48 134.26,139.83 132.94,141.15 128.52,141.15 128.27,140.89 128.27,135.64
+V3.3_WLAN on BOTTOM: 128.78,141 129.03,141 129.06,140.97 129.06,140.26 129.51,139.8 129.51,138.51 129.46,138.46 128.47,138.46 128.42,138.51 128.42,139.83 128.75,140.16 128.75,140.97
+V3.3NVME on TOP: 142.14,110.74 142.14,108.1 141.94,107.9 138.15,107.9 137.74,107.49 136.14,107.49 135.89,107.75 135.89,110.59 136.17,110.87 142.01,110.87
+V3.3NVME on BOTTOM: 152.68,114.81 155.35,114.81 155.6,114.55 155.6,113.41 156.49,112.52 157.63,112.52 157.76,112.39 157.76,110.36 157.51,110.11 155.6,110.11 154.97,110.74 153.07,110.74 152.15,110.57 150.96,109.95 149.32,108.51 142.54,108.51 141.91,107.87 139.06,107.87 138,106.81 135.08,106.81 134.92,106.96 134.92,108.41 135.13,108.61 139.24,108.61 139.78,109.14 141.73,110.69 143.23,111.2 144.83,111.3 149.71,111.3 150.27,111.33 150.77,111.89 152.43,113.54 152.43,114.55
+V3.3NVME on IN1: 153.34,116.33 157.89,116.33 158.27,115.95 158.27,110.62 157.76,110.11 155.47,110.11 154.84,110.74 151.41,110.74 149,108.33 146.56,108.33 145.72,107.49 136.19,107.49 135.41,108.28 135.41,115.16 135.66,115.42 152.43,115.42
+V3.3S on TOP (solid shape): 103.78,94.06 103.78,91.31 103.66,91.19 102.01,91.19 101.88,91.31 101.88,92.89 102.41,93.42 102.41,94.08 102.46,94.13 103.71,94.13
+V3.3S on TOP: 139.57,179.07 139.7,178.94 139.7,177.55 139.57,177.42 136.78,177.42 136.65,177.55 136.65,178.94 136.78,179.07
+V3.3S on TOP: 126.77,110.11 134.01,110.11 134.26,109.86 134.26,103.38 134.14,103.25 127.41,103.25 127.28,103.38 127.28,106.93 126.01,108.2 126.01,109.35
+V3.3S on TOP: 131.06,174.5 131.06,172.34 130.94,172.21 129.29,172.21 129.16,172.34 129.16,174.5 129.29,174.62 129.79,174.62 130.3,175.13 130.43,175.13
+V3.3S on BOTTOM: 134.67,108.69 134.67,103.28 134.26,102.87 125.76,102.87 125.5,103.12 125.5,108.71 125.81,109.02 134.34,109.02
+V3.3S on BOTTOM: 120.02,171.07 133.99,171.07 135.89,172.97 135.89,175.13 135.51,175.51 130.18,175.51 128.4,173.74 127.38,173.74 126.75,174.37 120.78,174.37 119.89,173.48 119.89,171.2
+V3.3S on IN1: 113.06,88.27 107.21,82.42 102.9,82.42 102.26,83.06 102.26,95.76 112.29,105.79 112.29,108.33 114.06,110.1 119.53,110.1 119.68,109.94 119.68,109.55 119.89,109.35 132.82,109.35 135.64,106.53 138.02,106.53 138.58,105.97 147.42,105.97 147.98,105.41 147.98,100.2 147.47,99.69 141.55,99.69 140.79,100.46 133.25,100.46 130.84,98.04 130.84,92.84 129.97,91.97 126.21,91.97 126.21,91.61 125.98,91.38 119.28,91.38 118.83,91.82 118.77,91.82 118.52,92.08 118.52,95.25 117.93,95.83 115.8,95.83 113.06,93.09
+V3.3S on IN2: 131.44,168.02 131.44,163.7 131.95,163.19 131.95,161.42 131.7,161.16 128.27,161.16 125.98,158.88 125.98,122.43 133.63,114.78 133.63,105.89 133.4,105.66 116.48,105.66 107.34,114.81 47.37,114.81 41.45,108.89 39.52,108.89 39.04,108.41 39.04,107.75 39.19,107.59 39.19,88.6 39.47,88.32 39.47,82.78 38.81,82.12 25.65,82.12 24.13,80.59 13.41,80.59 13.16,80.85 13.16,82.5 13.54,82.88 22.05,82.88 26.87,87.71 26.87,114.88 29.97,117.98 109.09,117.98 110.74,119.63 110.74,164.21 112.73,166.19 113.94,166.19 115.14,167.39 115.14,170 118.43,173.29 118.43,175.64 118.06,176.01 118.06,176.33 118.43,176.7 118.43,178.63 119.56,179.76 123.88,179.76 125.35,181.23 138.81,181.23 139.19,180.85 139.19,177.93 138.05,176.78 138.05,174.62
+V3.3S on IN3: 133.25,109.98 133.6,109.63 133.6,103.28 133.2,102.87 125.76,102.87 125.5,103.12 125.5,109.09 126.39,109.98
+V3.3SB on TOP (solid shape): 81.33,82.93 81.33,81.43 81.25,81.36 79.32,81.36 79.2,81.48 79.2,82.88 79.32,83.01 81.25,83.01
+V3.3SB on IN3 (solid shape): 131.72,101.98 131.72,98.55 130.84,97.66 130.84,91.69 130.71,91.57 125.88,91.57 125.76,91.69 125.76,98.3 127.79,100.33 127.79,101.98 127.91,102.11 131.6,102.11
+V3.3SB on TOP: 116,41.43 122.4,41.43 123.47,40.36 125.25,40.36 125.37,40.23 125.37,39.01 125.3,38.94 123.27,38.94 121.84,40.36 115.98,40.36 115.9,40.44 115.9,41.33
+V3.3SB on TOP: 127.66,101.85 130.71,101.85 130.84,101.73 130.84,91.69 130.71,91.57 125.88,91.57 125.76,91.69 125.76,97.41 127.53,99.19 127.53,101.73
+V3.3SB on TOP: 53.52,104.17 55.6,104.17 55.93,103.84 58.19,103.84 58.29,103.73 58.29,103.25 58.24,103.2 53.29,103.2 53.21,103.28 53.21,103.86
+V3.3SB on TOP: 93.22,41.33 93.22,39.88 92.84,39.5 87.25,39.5 86.49,40.26 34.54,40.26 34.42,40.39 34.42,42.37 34.75,42.7 40.34,42.7 41.4,41.63 92.91,41.63
+V3.3SB on BOTTOM: 131.6,102.11 131.72,101.98 131.72,98.55 130.84,97.66 130.84,91.69 130.71,91.57 125.88,91.57 125.76,91.69 125.76,98.3 127.79,100.33 127.79,101.98 127.91,102.11
+V3.3SB on BOTTOM: 139.57,177.32 140.57,177.32 140.6,177.31 140.61,177.29 140.61,177.01 140.44,176.83 140.44,176.33 139.73,175.62 139.73,174.93 139.67,174.88 138.86,174.88 138.76,174.98 138.76,177.47 138.81,177.52 139.37,177.52
+V3.3SB on BOTTOM: 129.06,141.25 129.05,141.22 129.03,141.2 128.78,141.2 128.6,141.38 128.04,141.38 127.41,142.01 127.41,143.05 127.51,143.15 129.01,143.15 129.06,143.1
+V3.3SB on IN2: outline of 108 points within 32.75,38.25 149.58,178.18 ; 1 cut-out
+V3.3SB on VCC: outline of 231 points within 32.51,13.97 153.16,42.55
+V3P3A_HUB on TOP: 82.02,81.36 81.94,81.43 81.94,82.91 82.04,83.01 83.87,83.01 83.97,82.91 83.97,81.43 83.9,81.36
+V3P3A_HUB on TOP: 77.11,60.63 77.9,60.63 78.46,60.07 78.46,59.21 78.41,59.16 77.17,59.16 77.04,59.28 77.04,60.55
+V3P3A_HUB on IN2: 91.4,74.87 91.64,74.63 91.64,59.51 89.99,57.86 73.23,57.86 71.83,59.26 71.83,61.8 70.56,63.07 70.56,69.55 76.61,75.59 76.61,76.96 82.45,82.8 83.97,82.8 91.4,75.37
+V5S on IN3 (solid shape): 120.29,101.47 123.22,101.47 123.47,101.22 123.47,93.47 123.22,93.22 117.12,93.22 116.99,93.34 116.99,101.98 117.25,102.23 119.53,102.23
+V5S on TOP: 110.11,51.74 111.56,51.74 111.63,51.66 111.63,50.42 111.58,50.37 110.08,50.37 110.03,50.42 110.03,51.66
+V5S on TOP: 135.89,169.54 137.54,169.54 137.67,169.42 137.67,167.13 136.65,166.12 135.25,166.12 135.13,166.24 135.13,168.78
+V5S on TOP: 27.94,183.9 27.94,181.1 28.19,180.85 29.46,180.85 29.59,180.72 29.59,178.28 29.49,178.18 25.93,178.18 25.78,178.33 25.78,183.9 25.91,184.02 27.81,184.02
+V5S on TOP: 145.52,153.59 145.62,153.49 145.62,152.35 145.57,152.3 144.5,152.3 144.35,152.15 143.41,152.15 143.18,152.37 143.18,153.24 143.54,153.59
+V5S on TOP: 117.12,101.35 123.34,101.35 123.47,101.22 123.47,93.73 122.96,93.22 115.85,93.22 115.72,93.34 115.72,97.16 116.99,98.42 116.99,101.22
+V5S on TOP: 70.03,135.76 86.49,135.76 86.97,135.28 86.97,132.77 86.79,132.59 85.32,132.59 84.99,132.92 84.99,133.32 84.86,133.45 84.84,133.45 84.73,133.55 83.26,133.55 82.98,133.27 82.98,132.69 82.88,132.59 81.61,132.59 81.48,132.72 81.48,133.25 81.28,133.45 79.04,133.45 78.94,133.35 78.94,132.66 78.87,132.59 77.55,132.59 77.44,132.69 77.44,133.2 77.19,133.45 75.16,133.45 75.03,133.32 75.03,132.72 74.9,132.59 73.51,132.59 73.43,132.66 73.43,133.15 73.15,133.43 71.32,133.43 70.99,133.1 70.99,132.72 70.87,132.59 69.62,132.59 69.47,132.74 69.47,135.2
+V5S on TOP: 90.25,156.03 91.77,156.03 91.9,155.91 91.9,154.25 91.77,154.13 90.25,154.13 90.12,154.25 90.12,155.91
+V5S on BOTTOM: 123.47,93.47 123.47,101.22 123.22,101.47 120.29,101.47 119.53,102.23 117.25,102.23 116.99,101.98 116.99,93.34 117.12,93.22 123.22,93.22
+V5S on BOTTOM: 25.91,184.02 27.81,184.02 27.94,183.9 27.94,181.36 30,179.3 30,176.53 29.87,176.4 28.22,176.4 28.09,176.53 28.09,178.05 26.7,179.45 25.91,179.45 25.78,179.58 25.78,183.9
+V5S on IN1: 115.98,95.38 117.75,95.38 118.01,95.12 118.01,93.09 117.75,92.84 115.47,92.84 114.71,92.08 114.71,90.81 115.09,90.42 115.09,85.72 113.82,84.45 113.82,81.03 109.37,76.58 106.2,76.58 104.67,75.06 104.67,70.74 103.63,69.7 97.46,69.7 96.98,69.22 94.13,69.22 93.88,69.47 93.88,70.87 94.26,71.25 96.06,71.25 100.24,75.43 100.24,81.17 100.99,81.92 107.37,81.92 113.44,87.99 113.44,92.84
+V5S on IN2: 101.63,51.94 111.33,51.94 111.58,51.69 111.58,49.07 110.39,47.88 92.35,47.88 89.81,50.42 77.5,50.42 74.32,53.59 74.32,56.9 74.57,57.15 90.96,57.15 96.72,62.92 96.72,68.55 96.27,69.01 93.88,69.01 93.75,69.14 93.75,70.36 94.01,70.61 97.43,70.61 99.47,68.58 99.47,54.1
+V5S on IN2: 25.7,183.08 28.02,183.08 28.27,182.83 28.27,178 29.03,177.24 35.18,177.24 37.08,175.34 40.84,175.34 46.05,170.13 69.29,170.13 69.93,170.76 79.71,170.76 82.3,173.35 85.06,173.35 85.47,172.95 85.47,170.56 86.75,169.28 86.75,164.73 88.77,162.71 88.77,160.78 88.9,160.66 90.83,160.66 91.02,160.46 91.02,157.54 91.19,157.38 91.67,157.38 91.9,157.15 91.9,139.01 85.8,132.92 69.29,132.92 68.78,133.43 68.78,163.78 67.01,165.56 39.19,165.56 34.75,170 25.86,170 25.43,170.43 25.43,182.8
+V5S on VCC: outline of 98 points within 62.48,93.09 127.38,135.13 ; 1 cut-out
+V5S on IN3: 136.65,168.53 136.4,168.28 131.57,168.28 123.44,176.4 90.55,176.4 84.84,170.69 80.92,170.69 80.47,171.15 80.47,180.26 81.43,181.23 135.41,181.23 136.65,179.98
+V5S_ISO on TOP: 78.57,183.88 78.97,184.28 78.97,187.02 78.69,187.3 77.11,187.3 77.09,187.32 75.62,187.32 73.91,189.03 70.28,189.03 70.13,188.87 70.13,187.15 70.47,186.8 70.75,186.8 71.31,186.25 71.31,185.48 71.3,185.47 71.3,184.02 71.44,183.88
+V5S_ISO on TOP: 62.1,185.04 62.23,185.17 63.37,185.17 63.5,185.29 63.5,187.2 63.37,187.32 62.74,187.32 62.61,187.45 62.61,188.09 62.87,188.34 62.87,188.72 62.74,188.85 60.96,188.85 60.83,188.72 60.83,182.7 61.01,182.52 61.9,182.52 62.1,182.73
+V5S_ISO on BOTTOM: 69.6,188.98 69.72,188.85 69.72,186.06 70.1,185.67 73.03,185.67 74.68,187.32 78.87,187.32 78.99,187.2 78.99,184.28 78.49,183.77 69.72,183.77 68.96,183.01 68.33,183.01 67.82,183.51 67.82,185.17 67.69,185.29 66.67,185.29 66.55,185.42 66.55,187.2 66.67,187.32 67.06,187.32 67.18,187.45 67.18,188.85 67.31,188.98
+V5S_ISO on IN1, IN2, IN3: 61.09,183.77 90.68,183.77 100.71,193.8 100.71,198.75 100.33,199.14 72.26,199.14 71.37,198.25 71.37,194.56 67.18,190.37 61.21,190.37 60.83,189.99 60.83,184.02
+V5SB on TOP (solid shape): 94.18,62.56 94.18,60.66 94.06,60.53 91.26,60.53 91.14,60.66 91.14,62.56 91.26,62.69 94.06,62.69
+V5SB on TOP (solid shape): 83.21,92.71 83.21,90.68 83.08,90.55 80.8,90.55 80.67,90.68 80.67,92.71 80.8,92.84 83.08,92.84
+V5SB on TOP (solid shape): 87.2,97.33 87.2,95.07 87.12,95 85.12,95 84.99,95.12 84.99,97.28 85.12,97.41 87.12,97.41
+V5SB on TOP: 45.29,92.41 44.93,92.76 42.47,92.76 42.39,92.84 42.39,93.04 42.27,93.17 41.45,93.17 41.43,93.19 41.43,93.45 41.45,93.47 47.85,93.47 47.87,93.46 48.3,93.46 48.46,93.29 48.46,91.26 48.21,91.01 45.42,91.01 45.29,91.14
+V5SB on TOP: 125.5,90.17 125.76,89.92 125.76,88.77 125.88,88.65 126.52,88.65 126.64,88.52 126.64,80.39 126.52,80.26 120.29,80.26 120.17,80.39 120.17,90.04 120.29,90.17
+V5SB on TOP: 45.29,102.06 44.91,102.44 42.44,102.44 42.39,102.49 42.39,102.69 42.27,102.82 41.45,102.82 41.43,102.84 41.43,103.1 41.45,103.12 47.85,103.12 47.87,103.11 48.3,103.11 48.46,102.95 48.46,100.91 48.21,100.66 45.42,100.66 45.29,100.79
+V5SB on TOP: 70.31,53 74.03,53 74.12,52.91 74.12,51.89 73.91,51.69 70.26,51.69 70.18,51.77 70.18,52.87
+V5SB on BOTTOM: 85.34,99.69 85.62,99.69 85.67,99.64 85.67,97.64 85.88,97.43 87.1,97.43 87.2,97.33 87.2,95.08 87.12,95 85.12,95 84.99,95.12 84.99,100.71 85.01,100.74 85.19,100.74 85.22,100.71 85.22,99.82
+V5SB on BOTTOM: 74.24,51.64 78.05,51.64 78.18,51.51 78.18,49.73 78.05,49.61 72.72,49.61 72.59,49.73 72.59,52.78 72.72,52.91 73.99,52.91 74.12,52.78 74.12,51.77
+V5SB on BOTTOM: 45.42,93.42 48.34,93.42 48.46,93.29 48.46,91.14 48.34,91.01 45.42,91.01 45.29,91.14 45.29,93.29
+V5SB on BOTTOM: 45.42,103.07 48.34,103.07 48.46,102.95 48.46,100.79 48.34,100.66 45.42,100.66 45.29,100.79 45.29,102.95
+V5SB on BOTTOM: 86.44,92.51 86.39,92.46 85.75,92.46 85.37,92.08 83.46,92.08 83.34,91.95 83.34,90.68 83.21,90.55 80.8,90.55 80.67,90.68 80.67,92.68 80.77,92.79 86.39,92.79 86.44,92.74
+V5SB on BOTTOM, IN3: 122.71,92.46 123.22,91.95 124.99,91.95 125.12,91.82 125.12,81.41 124.87,81.15 118.39,81.15 118.14,81.41 118.14,88.9 119.15,89.92 119.15,92.33 119.28,92.46
+V5SB on IN1: 120.35,90.02 125.15,90.02 125.37,89.79 125.37,80.8 125.2,80.62 120.12,80.62 119.81,80.92 119.81,89.48
+V5SB on VCC: outline of 142 points within 25.53,39.88 143.89,109.09 ; 3 cut-outs
+V12SB on IN3 (solid shape): 151.28,87.88 151.28,83.06 151.16,82.93 146.46,82.93 146.33,83.06 146.33,87.88 146.46,88.01 151.16,88.01
+V12SB on TOP: 52.78,165.18 67.51,165.18 67.77,164.92 67.77,159.21 67.64,159.08 64.85,159.08 64.34,158.57 58.75,158.57 58.5,158.32 58.5,157.05 58.37,156.92 52.65,156.92 52.4,157.18 52.4,164.8
+V12SB on TOP: 146.46,88.01 150.65,88.01 150.77,87.88 150.77,83.06 150.65,82.93 146.46,82.93 146.33,83.06 146.33,87.88
+V12SB on TOP: 145.57,96.39 145.57,97.92 146.46,98.81 150.01,98.81 150.14,98.68 150.14,96.39 150.01,96.27 145.69,96.27
+V12SB on BOTTOM: 144.93,96.27 144.68,96.52 143.94,96.52 143.89,96.57 143.89,97 143.92,97.03 145.19,97.03 145.54,97.38 145.54,97.89 146.46,98.81 150.01,98.81 150.14,98.68 150.14,96.39 150.01,96.27
+V12SB on BOTTOM: 51.89,165.05 66.88,165.05 67.13,164.8 67.13,159.08 66.62,158.57 51.77,158.57 51.64,158.7 51.64,164.8
+V12SB on BOTTOM: 146.46,88.01 151.16,88.01 151.28,87.88 151.28,83.06 151.16,82.93 146.46,82.93 146.33,83.06 146.33,87.88
+V12SB on VCC: outline of 147 points within 50.93,58.67 159.49,181.49 ; 1 cut-out
+V12SB on IN3: 144.93,96.27 144.68,96.52 143.94,96.52 143.89,96.57 143.89,97 143.92,97.03 145.19,97.03 145.54,97.38 145.54,97.89 146.46,98.81 149.76,98.81 149.94,98.63 149.94,96.47 149.73,96.27
AGND on BOTTOM (solid shape): 151.28,143.23 151.28,142.11 150.95,141.78 150.32,141.78 150.22,141.88 150.22,143.23 150.29,143.31 151.21,143.31
AGND on IN2 (solid shape): outline of 1310 points within 136.53,138.05 158.5,156.84
AGND on TOP: 136.53,144.02 137.92,144.02 138.43,144.53 138.68,144.53 138.81,144.4 138.81,142.75 139.32,142.24 143.64,142.24 144.02,142.62 144.02,144.4 144.4,144.78 151,144.78 151.38,144.4 151.38,142.27 148.82,139.7 140.08,139.7 139.95,139.83 139.95,140.59 139.57,140.97 139.57,141.27 139.37,141.48 138.94,141.48 138.56,141.1 137.54,141.1 137.16,140.72 136.78,140.72 136.4,141.1 136.4,143.89
AGND on BOTTOM: 136.6,139.45 137.16,139.45 137.29,139.57 137.29,140.97 137.79,141.48 137.79,142.49 137.72,142.57 136.58,142.57 136.53,142.52 136.53,139.52
AGND on GND1, VCC, GND2: 147.55,156.84 157.63,156.84 158.5,155.98 158.5,144.38 158.14,144.02 152.02,144.02 151.92,144 151.84,143.94 151.33,143.44 151.28,143.35 151.26,143.26 151.26,142.09 148.48,139.32 146.3,139.32 146.21,139.3 146.12,139.24 145.74,138.86 145.69,138.78 145.67,138.68 145.67,138.41 145.31,138.05 137.52,138.05 136.53,139.04 136.53,143.66 136.63,143.76 136.91,143.76 137,143.78 137.09,143.84 137.65,144.4 138.45,144.4 138.56,144.29 138.56,142.88 138.58,142.78 138.63,142.7 139.01,142.31 139.09,142.26 139.19,142.24 143.38,142.24 143.48,142.26 143.56,142.31 143.94,142.7 144,142.78 144.02,142.88 144.02,146.18 144.78,146.18 144.88,146.2 144.96,146.25 145.72,147.01 145.78,147.1 145.8,147.19 145.8,148.36 146.1,148.66 146.16,148.75 146.18,148.84 146.18,155.47
AVDD33_HUB on TOP: 78.87,59.87 80.21,59.87 80.26,59.82 80.26,58.72 80.19,58.65 79.3,58.65 78.82,59.13 78.82,59.82
AVDD33_HUB on IN3: 87.2,72.72 89.61,72.72 91.01,71.32 91.01,61.93 88.48,59.4 84.75,59.4 83.36,58.01 79.35,58.01 79.22,58.14 79.22,59.28 79.83,59.89 82.5,59.89 86.79,64.19 87.99,64.19 88.47,64.67 88.47,66.37 87.96,66.88 87.96,67.39 88.98,68.4 88.98,70.56 87.71,71.83 87.07,71.83 86.94,71.96 86.94,72.47
AVDD_CAM_2V8 on TOP: 125.22,176.78 129.92,176.78 130.05,176.66 130.05,175.51 129.41,174.88 125.22,174.88 125.09,175.01 125.09,176.66
AVDD_CAM_2V8 on BOTTOM: 131.57,178.94 132.46,178.94 132.59,178.82 132.59,177.67 132.46,177.55 131.95,177.55 131.83,177.42 130.68,177.42 128.14,174.88 120.4,174.88 119.19,173.67 119.19,170.75 117.73,169.29 117.73,165.48 115.19,162.94 114.05,162.94 113.92,163.07 113.92,166.62 114.55,167.26 114.55,169.04 113.41,170.18 113.41,173.61 117.73,177.93 127.76,177.93 128.27,178.44 131.06,178.44
DVDD10_HUB on IN1: 88.6,69.8 89.61,69.8 89.87,69.55 89.87,65.99 88.34,64.47 76.53,64.47 75.77,65.23 75.77,68.28 76.02,68.53 78.44,68.53 78.94,68.02 78.94,66.75 79.32,66.37 85.55,66.37 85.8,66.62 88.21,66.62 88.47,66.88 88.47,69.67
DVDD33_HUB on IN3: 85.93,64.59 87.83,64.59 88.21,64.97 88.21,66.12 87.71,66.62 87.71,68.53 88.6,69.42 88.6,70.31 87.45,71.45 84.15,71.45 83.39,72.21 77.67,72.21 75.26,69.8 75.26,68.78 75.39,68.66 78.18,68.66 79.2,69.67 85.55,69.67 85.67,69.55 85.67,64.85
GND on TOP (solid shape): 22.07,198.98 1.02,198.98 1.02,16.94 0.51,16.94 0.51,199.49 22.07,199.49
GND on TOP (solid shape): 43.13,31.7 43.13,28.22 43.08,28.17 39.6,28.17 39.52,28.24 39.52,31.7 39.62,31.8 43.03,31.8
GND on TOP (solid shape): 61.42,31.7 61.42,28.22 61.37,28.17 57.89,28.17 57.81,28.24 57.81,31.7 57.91,31.8 61.32,31.8
GND on TOP (solid shape): 72.8,111.76 72.8,109.37 72.53,109.11 68.97,109.11 68.86,109.22 68.86,111.63 69.49,112.27 72.29,112.27
GND on TOP (solid shape): 79.2,58.24 79.2,55.96 79.07,55.83 76.28,55.83 76.15,55.96 76.15,58.24 76.28,58.37 79.07,58.37
GND on TOP (solid shape): 79.71,31.7 79.71,28.22 79.65,28.17 76.17,28.17 76.1,28.24 76.1,31.7 76.2,31.8 79.6,31.8
GND on TOP (solid shape): 83.08,94.61 83.08,93.22 82.96,93.09 80.8,93.09 80.67,93.22 80.67,95.25 80.8,95.38 82.32,95.38
GND on TOP (solid shape): 96.85,53.8 96.85,51 96.72,50.88 93.04,50.88 92.91,51 92.91,53.8 93.04,53.92 96.72,53.92
GND on TOP (solid shape): 97.99,31.7 97.99,28.22 97.94,28.17 94.46,28.17 94.39,28.24 94.39,31.7 94.49,31.8 97.89,31.8
GND on TOP (solid shape): 116.28,31.7 116.28,28.22 116.23,28.17 112.75,28.17 112.67,28.24 112.67,31.7 112.78,31.8 116.18,31.8
GND on TOP (solid shape): 134.57,32.08 134.57,28.6 134.52,28.55 131.04,28.55 130.96,28.63 130.96,32.08 131.06,32.18 134.47,32.18
GND on TOP (solid shape): 88.8,97.28 88.8,95.48 88.67,95.35 87.53,95.35 87.45,95.43 87.45,97.33 87.53,97.41 88.67,97.41
GND on TOP (solid shape): 94.18,60.22 94.18,59.59 94.13,59.54 92.89,59.54 92.33,58.98 91.26,58.98 91.19,59.05 91.19,60.2 91.26,60.27 94.13,60.27
GND on TOP (solid shape): 47.27,58.93 47.27,57.48 47.14,57.35 46.05,57.35 46,57.4 46,58.67 46.33,59 47.19,59
GND on TOP (solid shape): 73.23,108.79 73.23,108.28 73.1,108.15 66.62,108.15 66.5,108.28 66.5,108.79 66.62,108.92 73.1,108.92
GND on TOP (solid shape): 83.34,90.17 83.34,88.65 83.21,88.52 80.8,88.52 80.67,88.65 80.67,90.17 80.8,90.3 83.21,90.3
GND on TOP (solid shape): 66.5,55.98 66.5,55.7 66.47,55.68 66.47,54.36 66.9,53.92 66.9,53.34 66.78,53.21 62.53,53.21 61.77,52.45 61.16,52.45 61.09,52.53 61.09,55.8 61.37,56.08 66.4,56.08
GND on TOP (solid shape): 159.49,58.7 158.98,58.7 158.98,181.98 159.02,182.02 159.06,182.06 159.06,183.32 159.03,183.35 158.98,183.4 158.98,183.41 158.67,183.72 158.67,185.69 158.98,186 158.98,198.98 103.15,198.98 103.15,199.49 159.49,199.49
GND on TOP (solid shape): 128.52,52.4 130.94,52.4 131.65,53.11 131.65,53.11 131.74,53.08 131.83,53.07 131.91,53.08 132,53.11 132.13,53.11 132.26,53.24 134.54,53.24 134.61,53.18 134.61,53 134.92,52.68 134.92,49.81 134.99,49.75 134.99,45.83 135.41,45.42 135.41,44.72 135.41,44.5 135.33,44.42 129.84,44.42 129.75,44.45 129.67,44.46 129.58,44.45 129.49,44.42 127.43,44.42 126.92,44.93 126.92,52.02 127,52.09 127,53.34 127.58,53.34
GND on TOP (solid shape): outline of 254 points within 6.75,183.5 15.75,192.5
GND on TOP (solid shape): outline of 254 points within 6.75,23.6 15.75,32.6
GND on TOP (solid shape): outline of 254 points within 144.25,160.6 153.25,169.6
GND on TOP (solid shape): outline of 254 points within 144.25,23.6 153.25,32.6
GND on BOTTOM (solid shape): 22.1,198.98 1.02,198.98 1.02,16.92 0.51,16.92 0.51,199.49 22.1,199.49
GND on BOTTOM (solid shape): 35.26,116.66 35.26,100.15 35,99.9 29.79,99.9 29.16,100.53 29.16,116.54 29.54,116.92 35,116.92
GND on BOTTOM (solid shape): 75.64,158.19 75.64,154.38 74.88,153.62 71.58,153.62 70.82,154.38 70.82,158.7 71.07,158.95 74.88,158.95
GND on BOTTOM (solid shape): 94.89,97.03 94.89,93.85 94.64,93.6 89.94,93.6 89.69,93.85 89.69,96.9 90.58,97.79 94.13,97.79
GND on BOTTOM (solid shape): 132.94,50.62 132.94,46.96 132.87,46.89 129.29,46.89 129.18,46.99 129.18,50.65 129.26,50.72 132.84,50.72
GND on BOTTOM (solid shape): 152.91,143.26 152.91,141.78 152.81,141.68 151.82,141.68 151.69,141.81 151.69,143.26 151.74,143.31 152.86,143.31
GND on BOTTOM (solid shape): 3.61,19.13 3.61,17.02 3.48,16.89 1.7,16.89 1.57,17.02 1.57,19.13 1.73,19.28 3.45,19.28
GND on BOTTOM (solid shape): 24.33,167.34 24.33,156.79 22.3,154.76 10.87,154.76 10.36,155.27 10.36,162.38 16.33,168.35 23.32,168.35
GND on BOTTOM (solid shape): 47.45,70.18 47.45,68.28 47.19,68.02 45.54,68.02 44.78,68.78 42.62,68.78 41.99,69.42 41.99,71.96 42.62,72.59 45.03,72.59
GND on BOTTOM (solid shape): 83.34,90.17 83.34,88.65 83.21,88.52 80.8,88.52 80.67,88.65 80.67,90.17 80.8,90.3 83.21,90.3
GND on BOTTOM (solid shape): 96.42,68.45 96.42,65.28 95.78,64.64 93.37,64.64 93.24,64.77 93.24,68.58 93.37,68.71 96.16,68.71
GND on BOTTOM (solid shape): 83.21,94.46 83.21,94.11 83.59,93.73 83.97,93.73 84.1,93.6 84.1,93.09 84.02,93.01 83.16,93.01 83.08,93.09 80.8,93.09 80.67,93.22 80.67,94.72 81.33,95.38 82.3,95.38
GND on BOTTOM (solid shape): 159.49,58.7 158.98,58.7 158.98,176.09 159.28,176.39 159.28,177.49 158.98,177.79 158.98,181.91 159.14,182.07 159.14,183.31 158.74,183.71 158.74,185.12 158.98,185.36 158.98,198.98 103.15,198.98 103.15,199.49 159.49,199.49
GND on BOTTOM (solid shape): outline of 254 points within 6.75,183.5 15.75,192.5
GND on BOTTOM (solid shape): outline of 254 points within 6.75,23.6 15.75,32.6
GND on BOTTOM (solid shape): outline of 254 points within 144.25,160.6 153.25,169.6
GND on BOTTOM (solid shape): outline of 254 points within 144.25,23.6 153.25,32.6
GND on IN1 (solid shape): 22.07,198.98 1.02,198.98 1.02,17.11 0.51,17.11 0.51,199.49 22.07,199.49
GND on IN1 (solid shape): 43.13,31.7 43.13,28.22 43.08,28.17 39.6,28.17 39.52,28.24 39.52,31.7 39.62,31.8 43.03,31.8
GND on IN1 (solid shape): 50.93,25.53 50.93,22 50.8,21.87 47.22,21.87 46.96,22.12 46.96,25.53 47.09,25.65 50.8,25.65
GND on IN1 (solid shape): 61.42,31.7 61.42,28.22 61.37,28.17 57.89,28.17 57.81,28.24 57.81,31.7 57.91,31.8 61.32,31.8
GND on IN1 (solid shape): 69.22,25.53 69.22,22 69.09,21.87 65.51,21.87 65.25,22.12 65.25,25.53 65.38,25.65 69.09,25.65
GND on IN1 (solid shape): 79.71,31.7 79.71,28.22 79.65,28.17 76.17,28.17 76.1,28.24 76.1,31.7 76.2,31.8 79.6,31.8
GND on IN1 (solid shape): 87.5,25.53 87.5,22 87.38,21.87 83.79,21.87 83.54,22.12 83.54,25.53 83.67,25.65 87.38,25.65
GND on IN1 (solid shape): 97.99,31.7 97.99,28.22 97.94,28.17 94.46,28.17 94.39,28.24 94.39,31.7 94.49,31.8 97.89,31.8
GND on IN1 (solid shape): 105.79,25.53 105.79,22 105.66,21.87 102.08,21.87 101.83,22.12 101.83,25.53 101.96,25.65 105.66,25.65
GND on IN1 (solid shape): 116.28,31.7 116.28,28.22 116.23,28.17 112.75,28.17 112.67,28.24 112.67,31.7 112.78,31.8 116.18,31.8
GND on IN1 (solid shape): 124.08,25.53 124.08,22 123.95,21.87 120.37,21.87 120.12,22.12 120.12,25.53 120.24,25.65 123.95,25.65
GND on IN1 (solid shape): 132.74,50.42 132.74,47.24 132.61,47.12 129.57,47.12 129.44,47.24 129.44,50.42 129.57,50.55 132.61,50.55
GND on IN1 (solid shape): 134.57,32.08 134.57,28.6 134.52,28.55 131.04,28.55 130.96,28.63 130.96,32.08 131.06,32.18 134.47,32.18
GND on IN1 (solid shape): 136.04,60.07 136.04,57.15 135.92,57.02 132.11,57.02 131.98,57.15 131.98,60.07 132.11,60.2 135.92,60.2
GND on IN1 (solid shape): 72.8,111.76 72.8,109.22 72.54,108.97 69.11,108.97 68.86,109.22 68.86,111.63 69.49,112.27 72.29,112.27
GND on IN1 (solid shape): 141.94,25.83 142.24,25.1 142.24,22 142.11,21.87 138.53,21.87 138.28,22.12 138.28,24.79 138.42,24.93 138.42,25.87 138.58,26.04 141.73,26.04
GND on IN1 (solid shape): 159.49,58.72 158.98,58.72 158.98,181.71 159.05,181.78 159.05,181.79 159.13,181.86 159.13,183.24 159.12,183.25 159.12,183.36 158.78,183.71 158.78,185.78 158.98,185.98 158.98,198.98 103.12,198.98 103.12,199.49 159.49,199.49
GND on IN2 (solid shape): 34.16,28.27 34.16,24.92 34.04,24.79 30.45,24.79 30.2,25.04 30.2,28.45 30.33,28.57 33.86,28.57
GND on IN2 (solid shape): 43.13,31.7 43.13,28.22 43.08,28.17 39.6,28.17 39.52,28.24 39.52,31.7 39.62,31.8 43.03,31.8
GND on IN2 (solid shape): 50.93,25.53 50.93,22 50.8,21.87 47.22,21.87 46.96,22.12 46.96,25.53 47.09,25.65 50.8,25.65
GND on IN2 (solid shape): 61.42,31.7 61.42,28.22 61.37,28.17 57.89,28.17 57.81,28.24 57.81,31.7 57.91,31.8 61.32,31.8
GND on IN2 (solid shape): 69.22,25.53 69.22,22 69.09,21.87 65.51,21.87 65.25,22.12 65.25,25.53 65.38,25.65 69.09,25.65
GND on IN2 (solid shape): 75.64,158.19 75.64,154.38 74.88,153.62 71.58,153.62 70.82,154.38 70.82,158.7 71.07,158.95 74.88,158.95
GND on IN2 (solid shape): 79.71,31.7 79.71,28.22 79.65,28.17 76.17,28.17 76.1,28.24 76.1,31.7 76.2,31.8 79.6,31.8
GND on IN2 (solid shape): 87.5,25.53 87.5,22 87.38,21.87 83.79,21.87 83.54,22.12 83.54,25.53 83.67,25.65 87.38,25.65
