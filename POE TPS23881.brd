# Allegro board POE TPS23881.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#875  -  []  156.41 191.47 90 top
NOREF#876  -  []  115.04 85.39 0 top
NOREF#877  -  []  79.49 36.63 0 top
NOREF#878  -  []  73.51 111.43 270 top
NOREF#879  -  []  137.85 88.39 0 top
NOREF#880  -  []  68.73 89.61 90 top
NOREF#881  -  []  53.04 31.48 0 top
NOREF#882  -  []  138.99 177.18 90 top
NOREF#883  -  []  65.61 29.86 270 top
NOREF#884  -  []  134.81 47.49 0 top
NOREF#885  -  []  113.87 157.78 270 top
NOREF#886  -  []  59.45 113.37 0 top
NOREF#887  -  []  34.46 31.65 0 top
NOREF#888  -  []  5.13 114.35 0 top
NOREF#889  -  []  20.71 28.18 0 top
NOREF#890  -  []  47.41 26.04 0 top
NOREF#891  -  []  54.31 77.85 270 top
NOREF#892  -  []  47.32 31.93 0 top
NOREF#893  -  []  76.89 99.75 270 top
NOREF#894  -  []  78.3 26.26 270 top
NOREF#895  -  []  98.69 96.11 0 top
NOREF#896  -  []  37.21 25.26 90 top
NOREF#897  -  []  56.29 171.32 0 top
NOREF#898  -  []  91.19 35.97 90 top
NOREF#899  -  []  124.41 44.84 0 top
NOREF#900  -  []  94.44 37.2 90 top
NOREF#901  -  []  153.14 17.02 270 top
NOREF#902  -  []  50.85 91.25 0 top
NOREF#903  -  []  65.61 31.93 0 top
NOREF#904  -  []  94.74 91.43 90 top
NOREF#905  -  []  63.96 102.08 270 top
NOREF#906  -  []  136.4 175.03 90 top
NOREF#907  -  []  62.51 61.59 0 top
NOREF#908  -  []  86.14 26.04 0 top
NOREF#909  -  []  126.95 41.39 0 top
NOREF#910  -  []  70.99 31.51 0 top
NOREF#911  -  []  141.66 121.28 0 top
NOREF#912  -  []  62.23 33.9 90 top
NOREF#913  -  []  151.41 17.5 270 top
NOREF#914  -  []  149.42 7.97 90 top
NOREF#915  -  []  148.01 131.11 270 top
NOREF#916  -  []  45.72 61.98 90 top
NOREF#917  -  []  75.39 37.17 270 top
NOREF#918  -  []  40.84 108.28 90 top
NOREF#919  -  []  15.06 39.87 0 top
NOREF#920  -  []  68.87 0.16 0 top
NOREF#921  -  []  109.91 152.86 90 top
NOREF#922  -  []  119.94 43.28 270 top
NOREF#923  -  []  93.43 37.2 90 top
NOREF#924  -  []  54.81 109.87 270 top
NOREF#925  -  []  138.2 40.67 90 top
NOREF#926  -  []  150.14 17.5 270 top
NOREF#927  -  []  67.67 110.06 0 top
NOREF#928  -  []  137.31 89.51 270 top
NOREF#929  -  []  50.06 48.92 0 top
NOREF#930  -  []  76.89 104.7 270 top
NOREF#931  -  []  34.49 191.36 90 top
NOREF#932  -  []  124.87 2.26 90 top
NOREF#933  -  []  144.22 98.76 90 top
NOREF#934  -  []  97.87 138 0 top
NOREF#935  -  []  54.05 77.81 270 top
NOREF#936  -  []  52.57 36.63 0 top
NOREF#937  -  []  134.82 178.61 0 top
NOREF#938  -  []  53.07 29.84 0 top
NOREF#939  -  []  136.53 63.5 0 top
NOREF#940  -  []  52.18 101.18 270 top
NOREF#941  -  []  126.99 42.16 0 top
NOREF#942  -  []  43.84 79.91 90 top
NOREF#943  -  []  131.2 54.81 0 top
NOREF#944  -  []  70.79 143.89 0 top
NOREF#945  -  []  47.07 28.52 0 top
NOREF#946  -  []  38.8 95.97 90 top
NOREF#947  -  []  15.31 21.79 90 top
NOREF#948  -  []  97.52 96.34 0 top
NOREF#949  -  []  98.11 97.76 0 top
NOREF#950  -  []  102.16 109.52 270 top
NOREF#951  -  []  49.81 106.81 0 top
NOREF#952  -  []  125.12 131.83 0 top
NOREF#953  -  []  75.08 37.52 0 top
NOREF#954  -  []  120.09 33.6 0 top
NOREF#955  -  []  52.55 103.53 0 top
NOREF#956  -  []  64.02 34.52 270 top
NOREF#957  -  []  134.86 49.15 0 top
NOREF#958  -  []  119.96 171.75 270 top
NOREF#959  -  []  115.82 119.79 90 top
NOREF#960  -  []  141.99 87.5 0 top
NOREF#961  -  []  57.78 72.17 90 top
NOREF#962  -  []  157.02 9.69 90 top
NOREF#963  -  []  126.01 54.43 0 top
NOREF#964  -  []  81.97 24.54 90 top
NOREF#965  -  []  135.97 176.45 0 top
NOREF#966  -  []  53.07 28.83 0 top
NOREF#967  -  []  149.66 75.44 0 top
NOREF#968  -  []  51.83 33.48 90 top
NOREF#969  -  []  84.56 92.41 0 top
NOREF#970  -  []  135.43 48.37 90 top
NOREF#971  -  []  42.91 36.63 0 top
NOREF#972  -  []  82.45 52.7 0 top
NOREF#973  -  []  125.09 39.4 0 top
NOREF#974  -  []  66.6 85.39 270 top
NOREF#975  -  []  126.23 27.94 0 top
NOREF#976  -  []  51.56 76.07 270 top
NOREF#977  -  []  119.38 181.99 0 top
NOREF#978  -  []  22.61 180.09 90 top
NOREF#979  -  []  141.29 62.36 0 top
NOREF#980  -  []  7.62 10.29 90 top
NOREF#981  -  []  132.03 165.91 0 top
NOREF#982  -  []  124.28 70.43 90 top
NOREF#983  -  []  104.87 2.26 90 top
NOREF#984  -  []  47.93 30.4 270 top
NOREF#985  -  []  61.7 52.78 270 top
NOREF#986  -  []  33.9 33.48 90 top
NOREF#987  -  []  131.52 155.02 90 top
NOREF#988  -  []  19.8 30.23 0 top
NOREF#989  -  []  132.7 42.24 0 top
NOREF#990  -  []  130.25 173.81 90 top
NOREF#991  -  []  132.4 26.04 0 top
NOREF#992  -  []  21.79 38.86 90 top
NOREF#993  -  []  147.73 122.1 270 top
NOREF#994  -  []  92 29.35 270 top
NOREF#995  -  []  54.4 73.14 90 top
NOREF#996  -  []  133.71 131.28 270 top
NOREF#997  -  []  144.7 104.95 270 top
NOREF#998  -  []  83.65 52.39 90 top
NOREF#999  -  []  139.85 107.28 90 top
NOREF#1000  -  []  29.32 30.42 90 top
NOREF#1001  -  []  137.92 120.76 90 top
NOREF#1002  -  []  116.2 73.08 270 top
NOREF#1003  -  []  55.83 17.09 90 top
NOREF#1004  -  []  51.13 75.62 270 top
NOREF#1005  -  []  65.61 29.58 0 top
NOREF#1006  -  []  126.19 31.86 0 top
NOREF#1007  -  []  69.6 80.39 270 top
NOREF#1008  -  []  108.71 6.91 90 top
NOREF#1009  -  []  107.01 38.24 0 top
NOREF#1010  -  []  55.55 53.14 270 top
NOREF#1011  -  []  122.81 171.45 270 top
NOREF#1012  -  []  102.22 33.15 0 top
NOREF#1013  -  []  91.43 26.54 0 top
NOREF#1014  -  []  38.96 92.79 0 top
NOREF#1015  -  []  69.16 81.48 0 top
NOREF#1016  -  []  117.09 34.43 270 top
NOREF#1017  -  []  65.61 28.33 0 top
NOREF#1018  -  []  149.2 69.39 0 top
NOREF#1019  -  []  124.1 43.81 0 top
NOREF#1020  -  []  107.61 32.28 0 top
NOREF#1021  -  []  151.21 90.75 0 top
NOREF#1022  -  []  73.1 75.64 0 top
NOREF#1023  -  []  133.16 26.04 90 top
NOREF#1024  -  []  140.34 78.27 90 top
NOREF#1025  -  []  31.17 30.98 90 top
NOREF#1026  -  []  132.33 165.35 0 top
NOREF#1027  -  []  35.05 36.59 270 top
NOREF#1028  -  []  117.6 43.28 270 top
NOREF#1029  -  []  20.85 28.22 90 top
NOREF#1030  -  []  81.41 34.48 270 top
NOREF#1031  -  []  42.98 125.78 270 top
NOREF#1032  -  []  92.02 60.87 270 top
NOREF#1033  -  []  129.24 138.1 0 top
NOREF#1034  -  []  138.76 32.31 0 top
NOREF#1035  -  []  135.18 89.66 0 top
NOREF#1036  -  []  137.24 104.09 0 top
NOREF#1037  -  []  59.88 91.68 0 top
NOREF#1038  -  []  147.65 109.65 270 top
NOREF#1039  -  []  134.85 88.09 0 top
NOREF#1040  -  []  95 25.69 90 top
NOREF#1041  -  []  89.65 28.83 0 top
NOREF#1042  -  []  107.61 31.65 0 top
NOREF#1043  -  []  156.54 177.5 90 top
NOREF#1044  -  []  128.92 36.65 90 top
NOREF#1045  -  []  19.51 80.59 90 top
NOREF#1046  -  []  55.75 145.93 90 top
NOREF#1047  -  []  60.82 60.66 0 top
NOREF#1048  -  []  98.98 91.68 90 top
NOREF#1049  -  []  127.97 31.89 0 top
NOREF#1050  -  []  134.4 147.83 0 top
NOREF#1051  -  []  99.01 35.51 90 top
NOREF#1052  -  []  102.5 93.93 90 top
NOREF#1053  -  []  43.46 64.77 0 top
NOREF#1054  -  []  110.3 54.06 90 top
NOREF#1055  -  []  127.71 166.17 270 top
NOREF#1056  -  []  66.88 100.15 0 top
NOREF#1057  -  []  89.89 31.79 270 top
NOREF#1058  -  []  67.11 188.16 90 top
NOREF#1059  -  []  151.59 151.46 0 top
NOREF#1060  -  []  109.2 151.47 0 top
NOREF#1061  -  []  131.43 26.04 90 top
NOREF#1062  -  []  119.42 181.74 0 top
NOREF#1063  -  []  62.42 101.51 0 top
NOREF#1064  -  []  133.73 155.55 270 top
NOREF#1065  -  []  47.65 186.94 90 top
NOREF#1066  -  []  3.2 54.69 0 top
NOREF#1067  -  []  114.11 25.65 0 top
NOREF#1068  -  []  157.05 184.92 0 top
NOREF#1069  -  []  143.28 105.66 0 top
NOREF#1070  -  []  127.53 65.43 0 top
NOREF#1071  -  []  62.1 63.12 270 top
NOREF#1072  -  []  125.22 133.88 90 top
NOREF#1073  -  []  68.15 84.12 270 top
NOREF#1074  -  []  150.12 9.69 0 top
NOREF#1075  -  []  81.86 35.51 90 top
NOREF#1076  -  []  68.59 89.57 90 top
NOREF#1077  -  []  136.56 63.75 0 top
NOREF#1078  -  []  116.92 39.7 90 top
NOREF#1079  -  []  87.22 93.04 90 top
NOREF#1080  -  []  93.02 100.18 0 top
NOREF#1081  -  []  45.42 61.14 270 top
NOREF#1082  -  []  118.61 27.61 0 top
NOREF#1083  -  []  50.52 46.94 0 top
NOREF#1084  -  []  124.45 50.55 0 top
NOREF#1085  -  []  136.91 17.44 90 top
NOREF#1086  -  []  71.02 26.12 270 top
NOREF#1087  -  []  157 182.12 0 top
NOREF#1088  -  []  38.48 86.49 90 top
NOREF#1089  -  []  80.47 18.72 270 top
NOREF#1090  -  []  152.2 192.23 90 top
NOREF#1091  -  []  125.9 32.66 0 top
NOREF#1092  -  []  126.99 41.53 0 top
NOREF#1093  -  []  135.08 17.09 90 top
NOREF#1094  -  []  49.61 143.56 270 top
NOREF#1095  -  []  58.24 170.89 0 top
NOREF#1096  -  []  126.87 5.46 270 top
NOREF#1097  -  []  60.91 113.37 270 top
NOREF#1098  -  []  77.97 18.41 90 top
NOREF#1099  -  []  139.22 78.27 90 top
NOREF#1100  -  []  73.33 37.39 270 top
NOREF#1101  -  []  70.94 28.69 0 top
NOREF#1102  -  []  141.69 121.54 0 top
NOREF#1103  -  []  147.4 129.49 0 top
NOREF#1104  -  []  44.27 79.45 90 top
NOREF#1105  -  []  129.41 65.43 90 top
NOREF#1106  -  []  121.23 78.28 0 top
NOREF#1107  -  []  60.48 64.14 0 top
NOREF#1108  -  []  71.32 32.12 0 top
NOREF#1109  -  []  17.78 109.22 90 top
NOREF#1110  -  []  58.7 166.75 0 top
NOREF#1111  -  []  126.75 143.48 270 top
NOREF#1112  -  []  57.1 37.17 270 top
NOREF#1113  -  []  63.12 34.48 270 top
NOREF#1114  -  []  135.22 38.33 0 top
NOREF#1115  -  []  32.92 193.93 270 top
NOREF#1116  -  []  111.53 62.61 90 top
NOREF#1117  -  []  78.44 26.23 270 top
NOREF#1118  -  []  54.74 145.92 0 top
NOREF#1119  -  []  6.93 108.41 90 top
NOREF#1120  -  []  138.38 177.46 0 top
NOREF#1121  -  []  53.7 166.7 0 top
NOREF#1122  -  []  93.04 176.73 0 top
NOREF#1123  -  []  74.14 199.69 0 top
NOREF#1124  -  []  121.74 27.42 0 top
NOREF#1125  -  []  122.25 137.11 270 top
NOREF#1126  -  []  62.98 34.52 0 top
NOREF#1127  -  []  84.41 97.96 0 top
NOREF#1128  -  []  125.35 55.85 270 top
NOREF#1129  -  []  115.77 73.53 270 top
NOREF#1130  -  []  34.53 37.85 0 top
NOREF#1131  -  []  96.01 91.43 90 top
NOREF#1132  -  []  102.44 102.82 0 top
NOREF#1133  -  []  149.66 72.77 0 top
NOREF#1134  -  []  55.04 35.51 90 top
NOREF#1135  -  []  62.87 35.97 90 top
NOREF#1136  -  []  128.27 165.85 90 top
NOREF#1137  -  []  109.93 62.63 90 top
NOREF#1138  -  []  142.72 96.32 0 top
NOREF#1139  -  []  149.15 134.54 270 top
NOREF#1140  -  []  98.84 65.91 0 top
NOREF#1141  -  []  133.87 54.94 90 top
NOREF#1142  -  []  124.41 51.32 0 top
NOREF#1143  -  []  89.61 31.76 270 top
NOREF#1144  -  []  131.8 172.75 90 top
NOREF#1145  -  []  49.01 112.13 270 top
NOREF#1146  -  []  118.57 27.47 0 top
NOREF#1147  -  []  39.45 65.07 270 top
NOREF#1148  -  []  135.25 142.8 90 top
NOREF#1149  -  []  39.45 108.28 90 top
NOREF#1150  -  []  146.86 191.19 270 top
NOREF#1151  -  []  82.03 29.21 0 top
NOREF#1152  -  []  140.82 106.93 0 top
NOREF#1153  -  []  139.34 172.72 0 top
NOREF#1154  -  []  57.61 82.93 90 top
NOREF#1155  -  []  73.71 27.44 270 top
NOREF#1156  -  []  138.07 78.27 90 top
NOREF#1157  -  []  51.89 58.2 270 top
NOREF#1158  -  []  54.36 57.28 90 top
NOREF#1159  -  []  99.16 98.09 0 top
NOREF#1160  -  []  66.83 55.52 0 top
NOREF#1161  -  []  14.38 108.74 0 top
NOREF#1162  -  []  66.57 103.66 90 top
NOREF#1163  -  []  144.37 100.51 270 top
NOREF#1164  -  []  21.07 39.19 0 top
NOREF#1165  -  []  54.74 151 0 top
NOREF#1166  -  []  65.47 91.68 0 top
NOREF#1167  -  []  129.15 24.18 270 top
NOREF#1168  -  []  139.78 180.1 0 top
NOREF#1169  -  []  98.81 65.66 0 top
NOREF#1170  -  []  134.05 26.04 0 top
NOREF#1171  -  []  145.62 141.58 0 top
NOREF#1172  -  []  52.55 194.36 90 top
NOREF#1173  -  []  151.92 20.09 0 top
NOREF#1174  -  []  100.15 138 0 top
NOREF#1175  -  []  89.61 29.98 270 top
NOREF#1176  -  []  7.32 71.58 90 top
NOREF#1177  -  []  60.78 59.39 0 top
NOREF#1178  -  []  115.87 88.14 0 top
NOREF#1179  -  []  139.24 120.42 90 top
NOREF#1180  -  []  144.73 92.02 0 top
NOREF#1181  -  []  154.06 118.37 0 top
NOREF#1182  -  []  45.92 144.7 0 top
NOREF#1183  -  []  73.1 30.75 270 top
NOREF#1184  -  []  118.61 34.52 0 top
NOREF#1185  -  []  79.73 109.3 90 top
NOREF#1186  -  []  60.12 166.32 90 top
NOREF#1187  -  []  75.46 100.46 0 top
NOREF#1188  -  []  68.58 182.28 90 top
NOREF#1189  -  []  53.26 58.6 270 top
NOREF#1190  -  []  32.92 190.91 90 top
NOREF#1191  -  []  127.99 67.01 0 top
NOREF#1192  -  []  46.37 0.56 90 top
NOREF#1193  -  []  38.96 91.64 0 top
NOREF#1194  -  []  151.94 122.1 270 top
NOREF#1195  -  []  137.03 75.06 0 top
NOREF#1196  -  []  18.29 109.22 90 top
NOREF#1197  -  []  79.65 41 0 top
NOREF#1198  -  []  95.87 91.39 90 top
NOREF#1199  -  []  38.28 177.5 90 top
NOREF#1200  -  []  119.51 134.47 270 top
NOREF#1201  -  []  121.06 68.86 90 top
NOREF#1202  -  []  142.26 62.11 90 top
NOREF#1203  -  []  88.4 33.48 90 top
NOREF#1204  -  []  141.58 149.38 90 top
NOREF#1205  -  []  134.8 134.7 90 top
NOREF#1206  -  []  100.63 96.7 0 top
NOREF#1207  -  []  18.16 80.63 90 top
NOREF#1208  -  []  144.38 63.24 90 top
NOREF#1209  -  []  98.25 98.34 270 top
NOREF#1210  -  []  2.03 10.29 0 top
NOREF#1211  -  []  61.54 91.64 270 top
NOREF#1212  -  []  52.2 72.14 90 top
NOREF#1213  -  []  62.37 33.86 90 top
NOREF#1214  -  []  89.14 36.63 0 top
NOREF#1215  -  []  79.18 25.65 0 top
NOREF#1216  -  []  73.65 25.22 0 top
NOREF#1217  -  []  58.09 93.04 0 top
NOREF#1218  -  []  83.93 32.51 0 top
NOREF#1219  -  []  123.77 46.89 90 top
NOREF#1220  -  []  133.21 53.64 0 top
NOREF#1221  -  []  141 126.62 0 top
NOREF#1222  -  []  133.07 87.96 0 top
NOREF#1223  -  []  45.42 62.53 270 top
NOREF#1224  -  []  21.35 39.19 90 top
NOREF#1225  -  []  132.36 164.21 0 top
NOREF#1226  -  []  146.81 95.63 90 top
NOREF#1227  -  []  15.1 40.01 0 top
NOREF#1228  -  []  133.55 182.83 90 top
NOREF#1229  -  []  146.18 113.11 270 top
NOREF#1230  -  []  74.65 53.54 0 top
NOREF#1231  -  []  59.75 113.03 270 top
NOREF#1232  -  []  100.13 65.61 90 top
NOREF#1233  -  []  75.46 105.54 0 top
NOREF#1234  -  []  123.52 76.4 90 top
NOREF#1235  -  []  98.73 100.71 0 top
NOREF#1236  -  []  140.59 79.24 90 top
NOREF#1237  -  []  115.25 109.22 0 top
NOREF#1238  -  []  67.49 80.39 270 top
NOREF#1239  -  []  49.56 71.83 90 top
NOREF#1240  -  []  128.65 24.14 270 top
NOREF#1241  -  []  49.99 75.62 270 top
NOREF#1242  -  []  55.42 83.95 270 top
NOREF#1243  -  []  41.55 79.91 90 top
NOREF#1244  -  []  119.42 180.72 0 top
NOREF#1245  -  []  151.59 139.52 0 top
NOREF#1246  -  []  75.14 37.2 90 top
NOREF#1247  -  []  145.95 99.23 90 top
NOREF#1248  -  []  151.56 19.94 90 top
NOREF#1249  -  []  18.02 32.77 0 top
NOREF#1250  -  []  152.48 21.41 270 top
NOREF#1251  -  []  124.7 33.86 0 top
NOREF#1252  -  []  65.1 66.62 0 top
NOREF#1253  -  []  145.43 109.66 270 top
NOREF#1254  -  []  64.72 102.08 270 top
NOREF#1255  -  []  142.82 105.23 0 top
NOREF#1256  -  []  128.92 42.24 90 top
NOREF#1257  -  []  111.2 158.32 0 top
NOREF#1258  -  []  152.04 146.94 0 top
NOREF#1259  -  []  14.17 106.12 90 top
NOREF#1260  -  []  142.47 66.88 90 top
NOREF#1261  -  []  75.46 106.17 0 top
NOREF#1262  -  []  134.82 176.73 90 top
NOREF#1263  -  []  87.3 176.86 90 top
NOREF#1264  -  []  54.61 35.97 90 top
NOREF#1265  -  []  46.81 58.66 90 top
NOREF#1266  -  []  95.15 58.04 0 top
NOREF#1267  -  []  70.94 28.97 270 top
NOREF#1268  -  []  93.12 106.81 270 top
NOREF#1269  -  []  52.22 143.13 0 top
NOREF#1270  -  []  141.12 107.28 90 top
NOREF#1271  -  []  9.73 53.54 0 top
NOREF#1272  -  []  98.54 96.86 0 top
NOREF#1273  -  []  104.39 26.29 0 top
NOREF#1274  -  []  145.44 104.52 0 top
NOREF#1275  -  []  135.2 44.56 0 top
NOREF#1276  -  []  144.98 101.8 0 top
NOREF#1277  -  []  103.3 139.88 270 top
NOREF#1278  -  []  142.65 134.49 0 top
NOREF#1279  -  []  89.61 32.12 0 top
NOREF#1280  -  []  46.94 31.72 90 top
NOREF#1281  -  []  41.27 112.12 270 top
NOREF#1282  -  []  98.11 98.37 270 top
NOREF#1283  -  []  64.82 189.03 270 top
NOREF#1284  -  []  126.57 51.57 0 top
NOREF#1285  -  []  138.69 121.73 90 top
NOREF#1286  -  []  110.29 29.35 270 top
NOREF#1287  -  []  102.22 28.83 0 top
NOREF#1288  -  []  137.49 182.83 0 top
NOREF#1289  -  []  138.3 17.44 90 top
NOREF#1290  -  []  132.07 55.42 0 top
NOREF#1291  -  []  41.27 108.74 90 top
NOREF#1292  -  []  74.85 88.16 90 top
NOREF#1293  -  []  150.91 192.53 0 top
NOREF#1294  -  []  53.04 28.33 270 top
NOREF#1295  -  []  28.21 36.78 90 top
NOREF#1296  -  []  34.79 27.56 0 top
NOREF#1297  -  []  132.67 56.34 90 top
NOREF#1298  -  []  71.49 36.63 270 top
NOREF#1299  -  []  120.47 28.97 0 top
NOREF#1300  -  []  135.38 34.81 270 top
NOREF#1301  -  []  102.18 33.29 0 top
NOREF#1302  -  []  110.49 36.31 90 top
NOREF#1303  -  []  58.24 109.91 0 top
NOREF#1304  -  []  128.64 36.65 0 top
NOREF#1305  -  []  131.09 125.86 0 top
NOREF#1306  -  []  84.48 108.25 90 top
NOREF#1307  -  []  126.61 50.67 0 top
NOREF#1308  -  []  51.1 104.83 270 top
NOREF#1309  -  []  57.4 23.76 270 top
NOREF#1310  -  []  134.37 149.35 0 top
NOREF#1311  -  []  31.2 40.39 0 top
NOREF#1312  -  []  146.47 141.86 0 top
NOREF#1313  -  []  145.44 102.23 0 top
NOREF#1314  -  []  74.19 53.11 0 top
NOREF#1315  -  []  93.37 37.52 0 top
NOREF#1316  -  []  20.52 25.97 90 top
NOREF#1317  -  []  139.85 107.28 90 top
NOREF#1318  -  []  98.7 101.6 0 top
NOREF#1319  -  []  136.81 113.65 90 top
NOREF#1320  -  []  89.65 32.26 0 top
NOREF#1321  -  []  134.01 131.62 270 top
NOREF#1322  -  []  60.58 17.44 90 top
NOREF#1323  -  []  36.19 18.41 90 top
NOREF#1324  -  []  152.1 114.86 270 top
NOREF#1325  -  []  93.68 107.11 270 top
NOREF#1326  -  []  150.75 120.78 90 top
NOREF#1327  -  []  64.58 101.51 0 top
NOREF#1328  -  []  144.98 191.47 90 top
NOREF#1329  -  []  48.59 27.42 0 top
NOREF#1330  -  []  152.63 87.58 0 top
NOREF#1331  -  []  144.98 105.23 0 top
NOREF#1332  -  []  141.6 18.41 90 top
NOREF#1333  -  []  101.98 63.75 270 top
NOREF#1334  -  []  126.95 41.03 0 top
NOREF#1335  -  []  6.12 55.49 270 top
NOREF#1336  -  []  81.15 35.97 90 top
NOREF#1337  -  []  67.61 85.39 270 top
NOREF#1338  -  []  47.32 32.65 0 top
NOREF#1339  -  []  62.43 35.51 0 top
NOREF#1340  -  []  58.88 83.91 270 top
NOREF#1341  -  []  12.32 106.58 90 top
NOREF#1342  -  []  115.19 17.44 90 top
NOREF#1343  -  []  58.66 92.9 90 top
NOREF#1344  -  []  63.7 29.07 0 top
NOREF#1345  -  []  120.51 32.51 0 top
NOREF#1346  -  []  34.42 32.14 90 top
NOREF#1347  -  []  53.04 31.76 270 top
NOREF#1348  -  []  119.08 181.43 0 top
NOREF#1349  -  []  9.07 76.78 90 top
NOREF#1350  -  []  137.69 102.23 0 top
NOREF#1351  -  []  132.99 88.65 0 top
NOREF#1352  -  []  39.9 64.64 0 top
NOREF#1353  -  []  32.92 193.07 0 top
NOREF#1354  -  []  107.9 29.71 0 top
NOREF#1355  -  []  42.91 36.63 270 top
NOREF#1356  -  []  92.57 23.8 0 top
NOREF#1357  -  []  18.75 108.92 0 top
NOREF#1358  -  []  128.78 36.69 90 top
NOREF#1359  -  []  12.22 81.18 0 top
NOREF#1360  -  []  125.72 37.01 270 top
NOREF#1361  -  []  19.8 32.13 0 top
NOREF#1362  -  []  146.25 98.88 90 top
NOREF#1363  -  []  131.8 85.29 90 top
NOREF#1364  -  []  127.66 76.2 0 top
NOREF#1365  -  []  101.07 95.28 90 top
NOREF#1366  -  []  56.38 18.41 90 top
NOREF#1367  -  []  99.69 34.48 270 top
NOREF#1368  -  []  102.18 29.58 0 top
NOREF#1369  -  []  44.88 67.61 270 top
NOREF#1370  -  []  12.14 82.09 0 top
NOREF#1371  -  []  40.84 110.16 0 top
NOREF#1372  -  []  122.68 70.89 90 top
NOREF#1373  -  []  135 184.11 270 top
NOREF#1374  -  []  29.5 191.26 0 top
NOREF#1375  -  []  150.67 115.57 0 top
NOREF#1376  -  []  138.8 33.53 0 top
NOREF#1377  -  []  60.78 63.58 0 top
NOREF#1378  -  []  47.8 144.7 270 top
NOREF#1379  -  []  52.74 31.65 0 top
NOREF#1380  -  []  31.29 31.45 90 top
NOREF#1381  -  []  53.8 56.97 0 top
NOREF#1382  -  []  50.89 91.39 0 top
NOREF#1383  -  []  135.66 89.41 0 top
NOREF#1384  -  []  132.84 54.85 90 top
NOREF#1385  -  []  95.82 25.65 0 top
NOREF#1386  -  []  65.35 26.34 0 top
NOREF#1387  -  []  83.93 28.83 0 top
NOREF#1388  -  []  140.34 184.11 270 top
NOREF#1389  -  []  88.52 12.4 0 top
NOREF#1390  -  []  139.34 75.34 90 top
NOREF#1391  -  []  64.39 61.59 270 top
NOREF#1392  -  []  122.72 26.04 0 top
NOREF#1393  -  []  50.44 53.11 90 top
NOREF#1394  -  []  34.42 17.44 90 top
NOREF#1395  -  []  50.44 99.59 0 top
NOREF#1396  -  []  47.93 30.3 90 top
NOREF#1397  -  []  140.28 47.19 0 top
NOREF#1398  -  []  137.24 45.83 90 top
NOREF#1399  -  []  26.15 38.81 90 top
NOREF#1400  -  []  26.78 38.81 0 top
NOREF#1401  -  []  94.69 109.91 0 top
NOREF#1402  -  []  27.93 28.56 0 top
NOREF#1403  -  []  28.07 36.82 90 top
NOREF#1404  -  []  60.19 109.43 90 top
NOREF#1405  -  []  133.96 130.3 90 top
NOREF#1406  -  []  127.58 164.01 270 top
NOREF#1407  -  []  120.85 18.72 0 top
NOREF#1408  -  []  150.57 178.1 270 top
NOREF#1409  -  []  61.68 91.68 270 top
NOREF#1410  -  []  127.46 54.43 0 top
NOREF#1411  -  []  134.75 131.28 270 top
NOREF#1412  -  []  144.73 122.1 0 top
NOREF#1413  -  []  156.7 55.37 0 top
NOREF#1414  -  []  139.12 103.81 270 top
NOREF#1415  -  []  34.53 33.48 0 top
NOREF#1416  -  []  135.25 177.19 90 top
NOREF#1417  -  []  73.56 79.63 0 top
NOREF#1418  -  []  62.61 71.88 270 top
NOREF#1419  -  []  100.94 97.69 0 top
NOREF#1420  -  []  47.42 72.95 90 top
NOREF#1421  -  []  113.14 25.65 90 top
NOREF#1422  -  []  85.42 190.83 0 top
NOREF#1423  -  []  58.66 93.94 270 top
NOREF#1424  -  []  115.98 120.55 0 top
NOREF#1425  -  []  129.92 24.14 270 top
NOREF#1426  -  []  126.03 182.04 270 top
NOREF#1427  -  []  81.55 34.52 270 top
NOREF#1428  -  []  125.97 33.86 0 top
NOREF#1429  -  []  134.95 102.67 270 top
NOREF#1430  -  []  39.22 86.92 0 top
NOREF#1431  -  []  40.84 110.69 0 top
NOREF#1432  -  []  4.95 84.86 90 top
NOREF#1433  -  []  145.16 92.48 90 top
NOREF#1434  -  []  66.5 157.94 0 top
NOREF#1435  -  []  108.03 60.04 0 top
NOREF#1436  -  []  124.28 66.37 90 top
NOREF#1437  -  []  90.53 98.86 0 top
NOREF#1438  -  []  80.38 34.47 0 top
NOREF#1439  -  []  63.4 188.59 0 top
NOREF#1440  -  []  19.3 109.22 90 top
NOREF#1441  -  []  99.44 139.42 270 top
NOREF#1442  -  []  40.96 25.63 0 top
NOREF#1443  -  []  114.43 135 270 top
NOREF#1444  -  []  139.32 183.13 90 top
NOREF#1445  -  []  56.18 149.17 90 top
NOREF#1446  -  []  142.93 67.31 0 top
NOREF#1447  -  []  138.85 26.42 0 top
NOREF#1448  -  []  140.77 174.55 270 top
NOREF#1449  -  []  116.61 132.21 0 top
NOREF#1450  -  []  82.14 104.85 0 top
NOREF#1451  -  []  110.03 70.11 90 top
NOREF#1452  -  []  114.3 157.33 270 top
NOREF#1453  -  []  128.77 142.93 0 top
NOREF#1454  -  []  144.86 181.43 90 top
NOREF#1455  -  []  128.46 54.69 90 top
NOREF#1456  -  []  35.64 192.23 0 top
NOREF#1457  -  []  132.72 6.81 90 top
NOREF#1458  -  []  133.68 176.45 0 top
NOREF#1459  -  []  45.97 138.68 0 top
NOREF#1460  -  []  85.42 176.86 0 top
NOREF#1461  -  []  34.75 29.71 0 top
NOREF#1462  -  []  74.85 86.06 90 top
NOREF#1463  -  []  151.5 98.44 90 top
NOREF#1464  -  []  75.05 18.41 90 top
NOREF#1465  -  []  92.98 36.27 90 top
NOREF#1466  -  []  40.39 102.01 90 top
NOREF#1467  -  []  149.52 149.48 0 top
NOREF#1468  -  []  60.78 82.63 0 top
NOREF#1469  -  []  76.89 100.89 270 top
NOREF#1470  -  []  38.51 92.08 0 top
NOREF#1471  -  []  52.18 37.72 0 top
NOREF#1472  -  []  116.07 36.63 0 top
NOREF#1473  -  []  121.08 33.64 90 top
NOREF#1474  -  []  111 23.76 270 top
NOREF#1475  -  []  109.68 138.25 0 top
NOREF#1476  -  []  14.83 107.65 0 top
NOREF#1477  -  []  7.65 78.36 0 top
NOREF#1478  -  []  126.75 140.49 90 top
NOREF#1479  -  []  127.97 27.55 0 top
NOREF#1480  -  []  107.9 28.69 0 top
NOREF#1481  -  []  56.71 77.84 90 top
NOREF#1482  -  []  73.25 82.5 0 top
NOREF#1483  -  []  36.56 27.3 0 top
NOREF#1484  -  []  146.96 88.64 90 top
NOREF#1485  -  []  66.22 31.93 270 top
NOREF#1486  -  []  134.62 34.81 270 top
NOREF#1487  -  []  126.61 53.09 0 top
NOREF#1488  -  []  107.9 28.97 270 top
NOREF#1489  -  []  26.56 37.39 270 top
NOREF#1490  -  []  44.69 34.52 0 top
NOREF#1491  -  []  58.57 82.63 0 top
NOREF#1492  -  []  88.98 110.29 270 top
NOREF#1493  -  [unnamed#2]  6.27 16.51 0 top
NOREF#1494  -  []  139.37 34.02 90 top
NOREF#1495  -  []  65.99 83.77 0 top
NOREF#1496  -  []  56.38 109.56 90 top
NOREF#1497  -  []  143.89 70.57 270 top
NOREF#1498  -  []  61.84 36.02 0 top
NOREF#1499  -  []  66.84 95.21 0 top
NOREF#1500  -  []  118.75 34.48 270 top
NOREF#1501  -  []  55.24 75.65 270 top
NOREF#1502  -  []  57.04 113.37 0 top
NOREF#1503  -  []  67.23 175.59 90 top
NOREF#1504  -  []  120.47 33.29 0 top
NOREF#1505  -  []  45.76 62.23 0 top
NOREF#1506  -  []  61.84 68.96 90 top
NOREF#1507  -  []  119.08 180.42 90 top
NOREF#1508  -  []  30.86 31.9 90 top
NOREF#1509  -  []  125.22 136.55 90 top
NOREF#1510  -  []  101.3 138 0 top
NOREF#1511  -  []  138.53 120.12 90 top
NOREF#1512  -  []  47.32 29.58 0 top
NOREF#1513  -  []  132.36 56.9 0 top
NOREF#1514  -  []  100.15 35.51 0 top
NOREF#1515  -  []  56.21 51.38 0 top
NOREF#1516  -  []  91.94 25.22 0 top
NOREF#1517  -  []  139.37 28.44 90 top
NOREF#1518  -  []  140.63 50.55 0 top
NOREF#1519  -  []  39.12 104.42 90 top
NOREF#1520  -  []  16.71 108.92 90 top
NOREF#1521  -  []  57.56 84.25 270 top
NOREF#1522  -  []  143.97 126.03 0 top
NOREF#1523  -  []  136.56 64.77 0 top
NOREF#1524  -  []  141.52 139.83 0 top
NOREF#1525  -  []  10.69 54.69 0 top
NOREF#1526  -  []  137.69 40.28 0 top
NOREF#1527  -  []  139.12 128.07 270 top
NOREF#1528  -  []  137.24 44.56 0 top
NOREF#1529  -  []  92.87 100.93 0 top
NOREF#1530  -  []  82.8 102.54 0 top
NOREF#1531  -  []  54.31 148.89 270 top
NOREF#1532  -  []  137.77 79.55 0 top
NOREF#1533  -  []  126.44 100 270 top
NOREF#1534  -  []  82.8 58.08 270 top
NOREF#1535  -  []  72.14 6.81 90 top
NOREF#1536  -  []  55.36 25.22 0 top
NOREF#1537  -  []  73.56 76.07 0 top
NOREF#1538  -  []  128.96 74.22 270 top
NOREF#1539  -  []  157.81 36.05 90 top
NOREF#1540  -  []  70.94 30.34 0 top
NOREF#1541  -  []  56.57 58.25 270 top
NOREF#1542  -  []  134.54 176.73 90 top
NOREF#1543  -  []  116.97 17.4 90 top
NOREF#1544  -  []  52.18 33.48 90 top
NOREF#1545  -  []  87.12 25.78 90 top
NOREF#1546  -  []  139.37 32.75 90 top
NOREF#1547  -  []  54.81 27.17 0 top
NOREF#1548  -  []  2.92 53.89 0 top
NOREF#1549  -  []  132.97 175.04 90 top
NOREF#1550  -  []  67.84 108.94 270 top
NOREF#1551  -  []  6.5 111.38 0 top
NOREF#1552  -  []  99.48 91.64 0 top
NOREF#1553  -  []  151.59 147.37 0 top
NOREF#1554  -  []  98.7 97.66 90 top
NOREF#1555  -  []  93.12 106.8 90 top
NOREF#1556  -  []  82.5 52.39 90 top
NOREF#1557  -  []  138.82 26.17 90 top
NOREF#1558  -  []  75.01 104.32 0 top
NOREF#1559  -  []  109.72 29.21 0 top
NOREF#1560  -  []  51.64 58.24 270 top
NOREF#1561  -  []  55.45 77.81 270 top
NOREF#1562  -  []  110.82 140.13 0 top
NOREF#1563  -  []  68.15 82.5 0 top
NOREF#1564  -  []  141.12 107.28 90 top
NOREF#1565  -  []  138.8 28.57 0 top
NOREF#1566  -  []  75.46 101.6 0 top
NOREF#1567  -  []  115.8 70.92 270 top
NOREF#1568  -  []  36.53 30.75 0 top
NOREF#1569  -  []  95 17.44 90 top
NOREF#1570  -  []  141.66 120.14 0 top
NOREF#1571  -  []  57.35 76 0 top
NOREF#1572  -  []  131.09 54.99 0 top
NOREF#1573  -  []  74.41 36.27 0 top
NOREF#1574  -  []  94.69 36.23 90 top
NOREF#1575  -  []  101.31 68.09 0 top
NOREF#1576  -  []  66.84 95.21 270 top
NOREF#1577  -  []  133.55 184.45 0 top
NOREF#1578  -  []  140.17 134.25 90 top
NOREF#1579  -  []  83.57 58.12 270 top
NOREF#1580  -  []  53.04 77.81 270 top
NOREF#1581  -  []  37.36 95.5 270 top
NOREF#1582  -  []  57.84 109.91 270 top
NOREF#1583  -  []  47.75 50.14 0 top
NOREF#1584  -  []  96.76 91.64 0 top
NOREF#1585  -  []  56.64 75.65 270 top
NOREF#1586  -  []  89 106.63 0 top
NOREF#1587  -  []  74.85 84.91 270 top
NOREF#1588  -  []  137.77 77.93 90 top
NOREF#1589  -  []  134.8 50.29 0 top
NOREF#1590  -  []  56.31 58.29 270 top
NOREF#1591  -  []  55.31 103.92 0 top
NOREF#1592  -  []  72.11 81.23 90 top
NOREF#1593  -  []  12.56 117.42 0 top
NOREF#1594  -  []  102.57 97.69 270 top
NOREF#1595  -  []  138.76 182.83 0 top
NOREF#1596  -  []  43.78 37.95 0 top
NOREF#1597  -  []  129.92 160.55 90 top
NOREF#1598  -  []  140.59 44.32 90 top
NOREF#1599  -  []  43.46 67.18 0 top
NOREF#1600  -  []  86.44 93.55 270 top
NOREF#1601  -  []  13.28 82.09 0 top
NOREF#1602  -  []  147.22 109.19 270 top
NOREF#1603  -  []  63.61 51.58 90 top
NOREF#1604  -  []  24.87 2.26 90 top
NOREF#1605  -  []  151.08 75.01 90 top
NOREF#1606  -  []  49.17 96.52 0 top
NOREF#1607  -  []  118.06 132.66 270 top
NOREF#1608  -  []  126.44 158.29 0 top
NOREF#1609  -  []  71.36 32.26 0 top
NOREF#1610  -  []  122.56 154.28 270 top
NOREF#1611  -  []  102.22 29.72 0 top
NOREF#1612  -  []  143.26 126.49 90 top
NOREF#1613  -  []  98.18 34.47 270 top
NOREF#1614  -  []  24.17 28.55 90 top
NOREF#1615  -  []  64.2 66.76 90 top
NOREF#1616  -  []  17.09 80.62 90 top
NOREF#1617  -  []  132.7 56.59 0 top
NOREF#1618  -  []  136.73 76.63 0 top
NOREF#1619  -  []  45.52 140.03 0 top
NOREF#1620  -  []  60.78 61.54 0 top
NOREF#1621  -  []  73.65 23.8 270 top
NOREF#1622  -  []  43.78 38.75 270 top
NOREF#1623  -  []  27.98 12.4 0 top
NOREF#1624  -  []  124.23 101.35 0 top
NOREF#1625  -  []  127.71 166.17 0 top
NOREF#1626  -  []  43.47 62.36 0 top
NOREF#1627  -  []  65.35 28.52 0 top
NOREF#1628  -  []  15.44 106.12 90 top
NOREF#1629  -  []  120.02 170.43 90 top
NOREF#1630  -  []  133.22 93.08 90 top
NOREF#1631  -  []  83.63 54.61 90 top
NOREF#1632  -  []  60.91 113.37 0 top
NOREF#1633  -  []  79.62 34.47 0 top
NOREF#1634  -  []  95.52 101.83 90 top
NOREF#1635  -  []  17.48 108.13 0 top
NOREF#1636  -  []  122.12 74.32 90 top
NOREF#1637  -  []  40.64 17.4 90 top
NOREF#1638  -  []  52.82 33.48 0 top
NOREF#1639  -  []  118.19 154.23 270 top
NOREF#1640  -  []  66.51 91.07 90 top
NOREF#1641  -  []  138.76 28.71 0 top
NOREF#1642  -  []  30.3 29.26 270 top
NOREF#1643  -  []  82.17 34.48 270 top
NOREF#1644  -  []  75.46 103.12 0 top
NOREF#1645  -  []  25.68 67.89 0 top
NOREF#1646  -  []  124.92 56.31 270 top
NOREF#1647  -  []  43.13 18.72 0 top
NOREF#1648  -  []  70.35 38.23 0 top
NOREF#1649  -  []  128.65 25.64 90 top
NOREF#1650  -  []  68.28 108.48 270 top
NOREF#1651  -  []  68.59 89.57 0 top
NOREF#1652  -  []  54.41 72.14 90 top
NOREF#1653  -  []  54.18 45.72 90 top
NOREF#1654  -  []  101.3 107.65 0 top
NOREF#1655  -  []  120.35 154.36 0 top
NOREF#1656  -  []  82.03 34.52 0 top
NOREF#1657  -  []  82.7 105.16 90 top
NOREF#1658  -  []  10.69 67.89 0 top
NOREF#1659  -  []  127.76 36.35 90 top
NOREF#1660  -  []  60.64 102.12 270 top
NOREF#1661  -  []  21.03 21.79 90 top
NOREF#1662  -  []  51.64 173.61 90 top
NOREF#1663  -  []  126.48 49.64 90 top
NOREF#1664  -  []  131.5 161.98 270 top
NOREF#1665  -  []  132.37 165.61 0 top
NOREF#1666  -  []  127.03 177.52 270 top
NOREF#1667  -  []  153.47 150.32 90 top
NOREF#1668  -  []  49.35 107.24 270 top
NOREF#1669  -  []  34.75 26.15 0 top
NOREF#1670  -  []  89.65 26.29 0 top
NOREF#1671  -  []  131.83 52.95 90 top
NOREF#1672  -  []  17.3 114.58 0 top
NOREF#1673  -  []  124.46 17.4 90 top
NOREF#1674  -  []  47.93 33.64 90 top
NOREF#1675  -  []  30.47 191.01 90 top
NOREF#1676  -  []  74.14 194.39 90 top
NOREF#1677  -  []  60.02 72.25 90 top
NOREF#1678  -  []  9.68 107.21 0 top
NOREF#1679  -  []  121.67 181.74 270 top
NOREF#1680  -  []  127.47 132.23 0 top
NOREF#1681  -  []  50.06 47.65 0 top
NOREF#1682  -  []  134.44 159.05 0 top
NOREF#1683  -  []  129.26 71.3 0 top
NOREF#1684  -  []  84.2 31.58 270 top
NOREF#1685  -  []  47.96 140.28 0 top
NOREF#1686  -  []  149.5 150.75 0 top
NOREF#1687  -  []  95.24 91.39 90 top
NOREF#1688  -  []  73.1 26.4 0 top
NOREF#1689  -  []  157.1 100.99 90 top
NOREF#1690  -  []  140.63 44.58 0 top
NOREF#1691  -  []  37.06 86.92 0 top
NOREF#1692  -  []  143.59 70.92 0 top
NOREF#1693  -  []  140.59 50.29 90 top
NOREF#1694  -  []  63.6 64.34 90 top
NOREF#1695  -  []  39.9 63.5 0 top
NOREF#1696  -  []  54.55 103.92 0 top
NOREF#1697  -  []  86.16 108.51 270 top
NOREF#1698  -  []  73.71 26.68 270 top
NOREF#1699  -  []  100.38 93.93 90 top
NOREF#1700  -  []  53.34 36.59 270 top
NOREF#1701  -  []  46.63 184.31 90 top
NOREF#1702  -  []  149.68 99.01 90 top
NOREF#1703  -  []  128.73 139.75 0 top
NOREF#1704  -  []  121.18 104.24 270 top
NOREF#1705  -  []  132.51 125.43 90 top
NOREF#1706  -  []  17.73 115.04 90 top
NOREF#1707  -  []  107.05 38.1 0 top
NOREF#1708  -  []  102.79 33.64 90 top
NOREF#1709  -  []  68.07 176.05 90 top
NOREF#1710  -  []  138.38 32.11 90 top
NOREF#1711  -  []  56.57 113.06 90 top
NOREF#1712  -  []  124.84 33.9 90 top
NOREF#1713  -  []  50.09 150.44 90 top
NOREF#1714  -  []  74.69 36.88 270 top
NOREF#1715  -  []  43.43 17.44 90 top
NOREF#1716  -  []  144.7 103.81 270 top
NOREF#1717  -  []  89.65 29.84 0 top
NOREF#1718  -  []  11.66 126.82 0 top
NOREF#1719  -  []  65.61 28.97 0 top
NOREF#1720  -  []  133.38 135.13 0 top
NOREF#1721  -  []  93.68 36.23 90 top
NOREF#1722  -  []  65.79 29.95 270 top
NOREF#1723  -  []  134.82 176.45 0 top
NOREF#1724  -  []  55.83 108.24 90 top
NOREF#1725  -  []  55.77 36.88 270 top
NOREF#1726  -  []  158.7 112.32 270 top
NOREF#1727  -  []  156.54 176.48 90 top
NOREF#1728  -  []  50.9 98.88 0 top
NOREF#1729  -  []  95.82 25.65 90 top
NOREF#1730  -  []  131.83 141.74 270 top
NOREF#1731  -  []  123.01 154.76 270 top
NOREF#1732  -  []  121.34 135.18 0 top
NOREF#1733  -  []  140.03 27.8 0 top
NOREF#1734  -  []  137.69 104.52 0 top
NOREF#1735  -  []  75.67 108.15 0 top
NOREF#1736  -  []  62.06 37.95 0 top
NOREF#1737  -  []  145.16 134.09 270 top
NOREF#1738  -  []  140.11 107.24 90 top
NOREF#1739  -  []  138.91 77.93 90 top
NOREF#1740  -  []  30.86 33.44 90 top
NOREF#1741  -  []  41.45 122.76 90 top
NOREF#1742  -  []  52.96 72.17 90 top
NOREF#1743  -  []  16.66 82.04 0 top
NOREF#1744  -  []  117.73 35.97 90 top
NOREF#1745  -  []  56.26 71.83 90 top
NOREF#1746  -  []  95.25 18.41 90 top
NOREF#1747  -  []  97.59 139.88 270 top
NOREF#1748  -  []  57.4 37.52 270 top
NOREF#1749  -  []  56.63 23.8 0 top
NOREF#1750  -  []  141.69 120.4 0 top
NOREF#1751  -  []  100.32 34.52 0 top
NOREF#1752  -  []  125.9 32.03 0 top
NOREF#1753  -  []  54.85 31.37 0 top
NOREF#1754  -  []  92.08 25.26 90 top
NOREF#1755  -  []  73.63 55.32 0 top
NOREF#1756  -  []  64.31 29.35 270 top
NOREF#1757  -  []  131.04 73.71 270 top
NOREF#1758  -  []  107.9 32.4 270 top
NOREF#1759  -  []  91.26 40.18 0 top
NOREF#1760  -  []  83.59 52.7 0 top
NOREF#1761  -  []  110.29 26.68 270 top
NOREF#1762  -  []  62.31 91.64 270 top
NOREF#1763  -  []  118.57 29.07 0 top
NOREF#1764  -  []  53.31 49.81 0 top
NOREF#1765  -  []  153.47 139.65 90 top
NOREF#1766  -  []  98.76 110.79 0 top
NOREF#1767  -  []  115.52 120.98 0 top
NOREF#1768  -  []  108.71 12.4 0 top
NOREF#1769  -  []  102.22 32.51 0 top
NOREF#1770  -  []  130.63 160.1 0 top
NOREF#1771  -  []  71.03 32.28 0 top
NOREF#1772  -  []  63.68 26.42 0 top
NOREF#1773  -  []  126.23 29.21 0 top
NOREF#1774  -  []  36.53 26.4 0 top
NOREF#1775  -  []  68.99 108.94 0 top
NOREF#1776  -  []  117.4 116.71 90 top
NOREF#1777  -  []  45.39 26.42 0 top
NOREF#1778  -  []  47.07 25.73 90 top
NOREF#1779  -  []  93.37 106.77 270 top
NOREF#1780  -  []  152.44 167.8 0 top
NOREF#1781  -  []  48.92 52.1 0 top
NOREF#1782  -  []  128.24 141.1 0 top
NOREF#1783  -  []  138.38 33.99 0 top
NOREF#1784  -  []  50.19 76.48 0 top
NOREF#1785  -  []  110.9 153.16 0 top
NOREF#1786  -  []  132.35 42.24 90 top
NOREF#1787  -  []  27.38 38.43 0 top
NOREF#1788  -  []  41.12 79.45 90 top
NOREF#1789  -  []  54.81 30.47 90 top
NOREF#1790  -  []  19.76 30.09 0 top
NOREF#1791  -  []  108.06 36.63 270 top
NOREF#1792  -  []  132.46 120.68 90 top
NOREF#1793  -  []  49.82 104.52 0 top
NOREF#1794  -  []  60.27 18.72 0 top
NOREF#1795  -  []  87.3 190.83 90 top
NOREF#1796  -  []  41.14 90.63 0 top
NOREF#1797  -  []  6.3 84.18 90 top
NOREF#1798  -  []  54.43 150.44 0 top
NOREF#1799  -  []  141.52 175.26 0 top
NOREF#1800  -  []  56.26 55.88 270 top
NOREF#1801  -  []  135.25 143.51 0 top
NOREF#1802  -  []  134.23 44.63 0 top
NOREF#1803  -  []  49.15 58.24 270 top
NOREF#1804  -  []  63.6 66.22 0 top
NOREF#1805  -  []  136.91 121.87 0 top
NOREF#1806  -  []  120.22 25.73 90 top
NOREF#1807  -  []  36.56 29.21 0 top
NOREF#1808  -  []  138.76 30.24 270 top
NOREF#1809  -  []  37.48 36.27 90 top
NOREF#1810  -  []  56.9 75.69 270 top
NOREF#1811  -  []  109.68 31.51 0 top
NOREF#1812  -  []  28.47 53.89 90 top
NOREF#1813  -  []  22.94 20.78 90 top
NOREF#1814  -  []  42.44 110.11 0 top
NOREF#1815  -  []  95.02 106.53 270 top
NOREF#1816  -  []  101.73 63.72 270 top
NOREF#1817  -  []  13.03 106.12 90 top
NOREF#1818  -  []  138.68 120.73 90 top
NOREF#1819  -  []  70.61 33.52 90 top
NOREF#1820  -  []  116.84 36.06 90 top
NOREF#1821  -  []  18.8 109.22 90 top
NOREF#1822  -  []  62.43 35.51 90 top
NOREF#1823  -  []  61.2 36.63 0 top
NOREF#1824  -  []  111.12 36.31 90 top
NOREF#1825  -  []  11 109.33 90 top
NOREF#1826  -  []  123.77 45.87 90 top
NOREF#1827  -  []  37.34 17.44 90 top
NOREF#1828  -  []  57.92 97.98 0 top
NOREF#1829  -  []  73.14 31.37 0 top
NOREF#1830  -  []  65.13 65.2 0 top
NOREF#1831  -  []  151.33 120.47 0 top
NOREF#1832  -  []  142.82 127.91 0 top
NOREF#1833  -  []  57.78 17.4 90 top
NOREF#1834  -  []  134.19 26.07 90 top
NOREF#1835  -  []  135.37 50.15 90 top
NOREF#1836  -  []  79.76 33.9 90 top
NOREF#1837  -  []  59.64 109.74 270 top
NOREF#1838  -  []  89.61 27.7 0 top
NOREF#1839  -  []  97.9 34.47 0 top
NOREF#1840  -  []  142.34 99.62 0 top
NOREF#1841  -  []  140.54 127.05 270 top
NOREF#1842  -  []  69.19 83.62 90 top
NOREF#1843  -  []  90.22 27.42 90 top
NOREF#1844  -  []  126.42 154.74 270 top
NOREF#1845  -  []  115.39 119.33 90 top
NOREF#1846  -  []  107.05 34.09 0 top
NOREF#1847  -  []  133.91 120.22 90 top
NOREF#1848  -  []  82.55 58.12 270 top
NOREF#1849  -  []  135.19 88.39 0 top
NOREF#1850  -  []  131.57 36.27 90 top
NOREF#1851  -  []  141.17 102.57 0 top
NOREF#1852  -  []  94.86 25.65 0 top
NOREF#1853  -  []  60.71 34.48 270 top
NOREF#1854  -  []  136.83 184.45 270 top
NOREF#1855  -  []  48.9 148.82 0 top
NOREF#1856  -  []  52.15 57.23 90 top
NOREF#1857  -  []  51.94 47.65 90 top
NOREF#1858  -  []  70.79 141.86 0 top
NOREF#1859  -  []  123.77 100.91 0 top
NOREF#1860  -  []  124.46 18.41 90 top
NOREF#1861  -  []  48.59 56.79 90 top
NOREF#1862  -  []  135.25 183.13 90 top
NOREF#1863  -  []  113.23 151.33 90 top
NOREF#1864  -  []  148.29 134.54 0 top
NOREF#1865  -  []  34.67 17.4 90 top
NOREF#1866  -  []  55.68 83.91 270 top
NOREF#1867  -  []  127.53 65.43 0 top
NOREF#1868  -  []  61.24 181.84 90 top
NOREF#1869  -  []  40.01 104.67 90 top
NOREF#1870  -  []  135.64 17.4 90 top
NOREF#1871  -  []  132.21 157.95 270 top
NOREF#1872  -  []  131.78 94.16 0 top
NOREF#1873  -  []  51.94 48.92 90 top
NOREF#1874  -  []  40.17 123.06 0 top
NOREF#1875  -  []  65.41 52.25 90 top
NOREF#1876  -  []  97.92 36.59 270 top
NOREF#1877  -  []  54.86 18.41 90 top
NOREF#1878  -  []  60.73 70.74 0 top
NOREF#1879  -  []  60.01 25.63 90 top
NOREF#1880  -  []  118.97 109.52 270 top
NOREF#1881  -  []  67.01 83.77 0 top
NOREF#1882  -  []  57.71 170.89 90 top
NOREF#1883  -  []  134.67 126.44 90 top
NOREF#1884  -  []  37.13 26.68 270 top
NOREF#1885  -  []  73.1 29.07 0 top
NOREF#1886  -  []  61.47 168.55 90 top
NOREF#1887  -  []  133.59 54.94 0 top
NOREF#1888  -  []  60.48 62.1 0 top
NOREF#1889  -  []  138.25 35.48 0 top
NOREF#1890  -  []  80.4 36.63 270 top
NOREF#1891  -  []  84.2 51.08 90 top
NOREF#1892  -  []  49.78 78.36 270 top
NOREF#1893  -  []  104.27 17.4 90 top
NOREF#1894  -  []  18.26 106.12 0 top
NOREF#1895  -  []  69.14 26.34 270 top
NOREF#1896  -  []  120.22 28.52 0 top
NOREF#1897  -  []  55.37 82.63 0 top
NOREF#1898  -  []  133.08 93.65 0 top
NOREF#1899  -  []  75.46 98.17 0 top
NOREF#1900  -  []  62.89 67.31 0 top
NOREF#1901  -  []  125.65 136.09 90 top
NOREF#1902  -  []  16.26 79.15 0 top
NOREF#1903  -  []  38.51 94.36 0 top
NOREF#1904  -  []  128 27.69 0 top
NOREF#1905  -  []  131.69 141.17 0 top
NOREF#1906  -  []  54.3 77.84 90 top
NOREF#1907  -  []  45.29 35.51 0 top
NOREF#1908  -  []  124.46 181.7 270 top
NOREF#1909  -  []  128.03 143.54 270 top
NOREF#1910  -  []  70.12 33.48 90 top
NOREF#1911  -  []  144.7 102.67 270 top
NOREF#1912  -  []  138.53 121.26 90 top
NOREF#1913  -  []  63.68 109.87 270 top
NOREF#1914  -  []  60.66 109.74 270 top
NOREF#1915  -  []  127.48 65.04 0 top
NOREF#1916  -  []  146.86 102.67 270 top
NOREF#1917  -  []  104.87 2.26 0 top
NOREF#1918  -  []  52.55 199.66 0 top
NOREF#1919  -  []  40.08 17.09 90 top
NOREF#1920  -  []  134.82 174.57 90 top
NOREF#1921  -  []  37.49 96.52 0 top
NOREF#1922  -  []  101.93 26.34 0 top
NOREF#1923  -  []  53.04 32.12 0 top
NOREF#1924  -  []  53.75 46.18 90 top
NOREF#1925  -  []  47.93 33.01 90 top
NOREF#1926  -  []  75.06 18.41 270 top
NOREF#1927  -  []  47.45 139.12 90 top
NOREF#1928  -  []  6.87 155.1 0 top
NOREF#1929  -  []  107.94 26.29 0 top
NOREF#1930  -  []  147.75 66.42 0 top
NOREF#1931  -  []  103.71 17.09 90 top
NOREF#1932  -  []  135.24 34.85 0 top
NOREF#1933  -  []  114.94 133.99 90 top
NOREF#1934  -  []  20.57 39.23 90 top
NOREF#1935  -  []  138 17.09 90 top
NOREF#1936  -  []  108.62 155.57 0 top
NOREF#1937  -  []  123.7 154.27 270 top
NOREF#1938  -  []  145.11 184.23 0 top
NOREF#1939  -  []  62.1 109.56 270 top
NOREF#1940  -  []  98.84 91.64 90 top
NOREF#1941  -  []  63.96 177.47 0 top
NOREF#1942  -  []  102.22 33.78 0 top
NOREF#1943  -  []  106.87 5.46 270 top
NOREF#1944  -  []  135.33 74.75 90 top
NOREF#1945  -  []  96.58 25.65 90 top
NOREF#1946  -  []  115.8 70.92 0 top
NOREF#1947  -  []  143.66 100.05 270 top
NOREF#1948  -  []  39.57 36.2 90 top
NOREF#1949  -  []  71.25 33.52 90 top
NOREF#1950  -  []  142.29 26.72 270 top
NOREF#1951  -  []  116.09 134.24 270 top
NOREF#1952  -  []  43.55 36.02 0 top
NOREF#1953  -  []  62.48 113.07 270 top
NOREF#1954  -  []  27.55 194.36 90 top
NOREF#1955  -  []  54.94 187.83 90 top
NOREF#1956  -  []  126.11 33.9 90 top
NOREF#1957  -  []  141.38 107.24 90 top
NOREF#1958  -  []  120.27 171.41 270 top
NOREF#1959  -  []  101.73 106.65 270 top
NOREF#1960  -  []  137.39 88.82 270 top
NOREF#1961  -  []  91.43 31.37 0 top
NOREF#1962  -  []  156.64 25.07 0 top
NOREF#1963  -  []  142.06 176.61 0 top
NOREF#1964  -  []  46 72.26 270 top
NOREF#1965  -  []  124.16 182.04 0 top
NOREF#1966  -  []  144.65 17.4 90 top
NOREF#1967  -  []  58.43 113.37 0 top
NOREF#1968  -  []  126.23 30.23 0 top
NOREF#1969  -  []  11.26 71.35 90 top
NOREF#1970  -  []  77.42 18.72 0 top
NOREF#1971  -  []  134.23 54.94 90 top
NOREF#1972  -  []  109.91 155.27 90 top
NOREF#1973  -  []  123.39 154.61 270 top
NOREF#1974  -  []  132.7 54.81 90 top
NOREF#1975  -  []  127.67 73.91 0 top
NOREF#1976  -  []  103.3 104.7 270 top
NOREF#1977  -  []  84.07 29.95 270 top
NOREF#1978  -  []  46.38 144.27 0 top
NOREF#1979  -  []  46.81 35.1 0 top
NOREF#1980  -  []  107.9 31.76 270 top
NOREF#1981  -  []  6.17 71.58 90 top
NOREF#1982  -  []  141.34 177.92 270 top
NOREF#1983  -  []  150.88 191.13 90 top
NOREF#1984  -  []  121.67 181.73 90 top
NOREF#1985  -  []  45.45 34.52 0 top
NOREF#1986  -  []  74.42 85.6 90 top
NOREF#1987  -  []  47.36 33.78 0 top
NOREF#1988  -  []  93.07 107.11 0 top
NOREF#1989  -  []  56.18 146.89 90 top
NOREF#1990  -  []  76.89 102.29 270 top
NOREF#1991  -  []  25.27 53.89 0 top
NOREF#1992  -  []  67.72 79.53 0 top
NOREF#1993  -  []  97.4 91.64 90 top
NOREF#1994  -  []  135.23 90.37 0 top
NOREF#1995  -  []  67.26 56.95 270 top
NOREF#1996  -  []  102.22 28.19 0 top
NOREF#1997  -  []  134.61 42.24 0 top
NOREF#1998  -  []  116.54 108.92 90 top
NOREF#1999  -  []  146.41 87.33 90 top
NOREF#2000  -  []  18.31 187.71 90 top
NOREF#2001  -  []  0 0 0 top
NOREF#2002  -  []  100.28 26.71 0 top
NOREF#2003  -  []  53.04 28.97 270 top
NOREF#2004  -  []  66.09 175.59 90 top
NOREF#2005  -  []  85.17 27.7 270 top
NOREF#2006  -  []  127.66 75.06 0 top
NOREF#2007  -  []  65.61 33.29 0 top
NOREF#2008  -  []  150.91 176.66 0 top
NOREF#2009  -  []  45.39 24.54 90 top
NOREF#2010  -  []  99.32 52.51 90 top
NOREF#2011  -  []  24.77 179.12 270 top
NOREF#2012  -  []  54.56 113.37 270 top
NOREF#2013  -  []  9.73 82.09 0 top
NOREF#2014  -  []  64.52 67.31 270 top
NOREF#2015  -  []  37.82 105.87 0 top
NOREF#2016  -  []  152.53 137.15 90 top
NOREF#2017  -  []  89.78 33.65 90 top
NOREF#2018  -  []  124.41 41.77 0 top
NOREF#2019  -  []  22.38 20.47 90 top
NOREF#2020  -  []  118.57 26.71 0 top
NOREF#2021  -  []  139.09 140.18 0 top
NOREF#2022  -  []  22.76 40.18 0 top
NOREF#2023  -  []  21.65 26.54 0 top
NOREF#2024  -  []  89.14 36.63 270 top
NOREF#2025  -  []  126.3 88.27 0 top
NOREF#2026  -  []  134.54 69.22 0 top
NOREF#2027  -  []  15.32 20.78 90 top
NOREF#2028  -  []  53.98 52.83 270 top
NOREF#2029  -  []  134.06 146.35 0 top
NOREF#2030  -  []  138.25 34.62 90 top
NOREF#2031  -  []  56.13 108.58 90 top
NOREF#2032  -  []  94.51 101.83 0 top
NOREF#2033  -  []  131.52 155.88 0 top
NOREF#2034  -  []  73.38 110.03 0 top
NOREF#2035  -  []  115.04 84.53 90 top
NOREF#2036  -  []  11.89 106.12 0 top
NOREF#2037  -  []  116.95 34.47 0 top
NOREF#2038  -  []  100.69 94.49 0 top
NOREF#2039  -  []  120.52 30.61 90 top
NOREF#2040  -  []  56.06 145.87 90 top
NOREF#2041  -  []  113.28 35.89 90 top
NOREF#2042  -  []  136.73 35.89 90 top
NOREF#2043  -  []  45.29 35.51 90 top
NOREF#2044  -  []  47.93 32.37 90 top
NOREF#2045  -  []  137.27 45.34 0 top
NOREF#2046  -  []  57.29 91.53 270 top
NOREF#2047  -  []  85.29 106.63 0 top
NOREF#2048  -  []  144.07 133.78 270 top
NOREF#2049  -  []  45.72 63.75 0 top
NOREF#2050  -  []  141.22 103.89 270 top
NOREF#2051  -  []  63.2 66.75 0 top
NOREF#2052  -  []  107.94 32.26 0 top
NOREF#2053  -  []  12.14 20.82 90 top
NOREF#2054  -  []  132.21 92.74 90 top
NOREF#2055  -  []  115.49 86.11 0 top
NOREF#2056  -  []  85.04 103.68 0 top
NOREF#2057  -  []  47.32 33.92 0 top
NOREF#2058  -  []  98.17 18.41 90 top
NOREF#2059  -  []  10.69 108.99 90 top
NOREF#2060  -  []  135.15 88.14 90 top
NOREF#2061  -  []  128.98 72.95 270 top
NOREF#2062  -  []  74.63 51.28 90 top
NOREF#2063  -  []  58.52 72.11 0 top
NOREF#2064  -  []  112.13 23.8 270 top
NOREF#2065  -  []  151.22 102.19 0 top
NOREF#2066  -  []  136.91 120.73 0 top
NOREF#2067  -  []  126.23 26.67 0 top
NOREF#2068  -  []  83.52 18.72 270 top
NOREF#2069  -  []  88.85 106.22 270 top
NOREF#2070  -  []  134.4 147.19 0 top
NOREF#2071  -  []  82.21 105.66 270 top
NOREF#2072  -  []  142.65 135.89 0 top
NOREF#2073  -  []  138.81 32.56 90 top
NOREF#2074  -  []  120.22 134.92 270 top
NOREF#2075  -  []  138.68 127.61 270 top
NOREF#2076  -  []  152.68 17.5 270 top
NOREF#2077  -  []  110.82 138.25 90 top
NOREF#2078  -  []  123.39 152.98 0 top
NOREF#2079  -  []  52.96 58.25 270 top
NOREF#2080  -  []  158.7 111.3 270 top
NOREF#2081  -  []  91.03 99.91 0 top
NOREF#2082  -  []  76.57 26.26 270 top
NOREF#2083  -  []  139.9 89.46 270 top
NOREF#2084  -  []  50.9 52.27 0 top
NOREF#2085  -  []  37.03 17.09 90 top
NOREF#2086  -  []  73.38 108.15 90 top
NOREF#2087  -  []  132.61 73.41 270 top
NOREF#2088  -  []  17.98 32.63 0 top
NOREF#2089  -  []  28.71 30.42 0 top
NOREF#2090  -  []  115.52 122.61 0 top
NOREF#2091  -  []  146.18 113.11 0 top
NOREF#2092  -  []  134.06 150.95 0 top
NOREF#2093  -  []  142.66 120.15 90 top
NOREF#2094  -  []  125.48 181.74 270 top
NOREF#2095  -  []  48.13 12.5 0 top
NOREF#2096  -  []  106.93 139.97 270 top
NOREF#2097  -  []  128.75 42.48 270 top
NOREF#2098  -  []  140.28 44.27 90 top
NOREF#2099  -  []  61.79 62.56 90 top
NOREF#2100  -  []  113.28 25.69 90 top
NOREF#2101  -  []  157.38 111.25 0 top
NOREF#2102  -  []  157.66 184.01 90 top
NOREF#2103  -  []  56.82 56.18 270 top
NOREF#2104  -  []  144.83 173.69 0 top
NOREF#2105  -  []  55.5 75.68 90 top
NOREF#2106  -  []  18.26 34.71 270 top
NOREF#2107  -  []  131.98 155.45 0 top
NOREF#2108  -  []  142.82 104.09 0 top
NOREF#2109  -  []  97.92 17.44 90 top
NOREF#2110  -  []  113.14 25.65 0 top
NOREF#2111  -  []  156.84 176.91 90 top
NOREF#2112  -  []  100.15 35.51 90 top
NOREF#2113  -  []  61.79 63.58 90 top
NOREF#2114  -  []  137.96 136 0 top
NOREF#2115  -  []  135.63 18.41 90 top
NOREF#2116  -  []  57 84.25 270 top
NOREF#2117  -  []  56.82 72.14 90 top
NOREF#2118  -  []  149.86 134.09 270 top
NOREF#2119  -  []  143 120.73 90 top
NOREF#2120  -  []  144.86 175.08 90 top
NOREF#2121  -  []  137.16 18.41 90 top
NOREF#2122  -  []  135.7 89.66 0 top
NOREF#2123  -  []  9.73 80.21 90 top
NOREF#2124  -  []  83.39 35.1 0 top
NOREF#2125  -  []  48.64 56.26 270 top
NOREF#2126  -  []  151.08 68.53 90 top
NOREF#2127  -  []  72.21 141.43 90 top
NOREF#2128  -  []  116.7 36.02 0 top
NOREF#2129  -  []  157.77 112.2 90 top
NOREF#2130  -  []  136.07 130.3 90 top
NOREF#2131  -  []  138.02 89.46 0 top
NOREF#2132  -  []  27.55 199.66 0 top
NOREF#2133  -  []  45.45 26.85 0 top
NOREF#2134  -  []  140.61 72.01 0 top
NOREF#2135  -  []  103.36 51.83 90 top
NOREF#2136  -  []  140.82 106.93 0 top
NOREF#2137  -  []  62.94 176.73 90 top
NOREF#2138  -  []  158.57 25.98 270 top
NOREF#2139  -  []  129.27 36.65 0 top
NOREF#2140  -  []  140.59 45.85 90 top
NOREF#2141  -  []  72.72 84.56 270 top
NOREF#2142  -  []  83.52 18.72 0 top
NOREF#2143  -  []  62.69 177.47 270 top
NOREF#2144  -  []  101.45 51.83 90 top
NOREF#2145  -  []  138.91 43.51 0 top
NOREF#2146  -  []  139.37 30.78 270 top
NOREF#2147  -  []  21.65 25.93 90 top
NOREF#2148  -  []  129.53 44.02 0 top
NOREF#2149  -  []  27.71 167.89 270 top
NOREF#2150  -  []  103.18 67.09 90 top
NOREF#2151  -  []  39.45 61.52 270 top
NOREF#2152  -  []  54.81 31.23 90 top
NOREF#2153  -  []  54.81 109.87 0 top
NOREF#2154  -  []  28.52 38.43 90 top
NOREF#2155  -  []  92.33 61.21 270 top
NOREF#2156  -  []  132.92 134.7 0 top
NOREF#2157  -  []  84.6 93.31 0 top
NOREF#2158  -  []  97.61 17.09 90 top
NOREF#2159  -  []  136.86 29.45 0 top
NOREF#2160  -  []  50.44 100.46 270 top
NOREF#2161  -  []  112.67 37.52 0 top
NOREF#2162  -  []  41 99.92 90 top
NOREF#2163  -  []  91.94 25.22 90 top
NOREF#2164  -  []  52.27 75.62 270 top
NOREF#2165  -  []  137.26 25.37 90 top
NOREF#2166  -  []  46.34 71.96 0 top
NOREF#2167  -  []  66.84 100.29 0 top
NOREF#2168  -  []  100.25 26.42 0 top
NOREF#2169  -  []  135.97 174.57 90 top
NOREF#2170  -  []  34.09 28.65 90 top
NOREF#2171  -  []  136.83 26.8 0 top
NOREF#2172  -  []  137.27 46.61 0 top
NOREF#2173  -  []  22.38 22.1 0 top
NOREF#2174  -  []  50.62 77.9 270 top
NOREF#2175  -  []  102.79 28.05 90 top
NOREF#2176  -  []  85.06 101.55 0 top
NOREF#2177  -  []  47.5 29.95 270 top
NOREF#2178  -  []  136.27 184.15 270 top
NOREF#2179  -  []  67.06 85.09 270 top
