# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UPE_TXN0: length 6.9
  TOP w0.114: U70.50 55.76,70.71 55.83,70.79 55.83,76.49 CM52.1
UPE_TXN1: length 4.7
  TOP w0.114: CM54.1 54.63,74.31 54.63,70.81 54.56,70.74 U70.53
UPE_TXP0: length 6.9
  TOP w0.114: U70.49 56.16,70.71 56.09,70.79 56.09,76.49 CM53.1
UPE_TXP1: length 4.7
  TOP w0.114: CM55.1 54.89,74.36 54.89,70.81 54.96,70.74 U70.52
UPHY0_RX2_N: length 52.6
  TOP w0.102: v3(82.52,121.5) 82.39,121.37 82.39,121.01 82.55,120.86 J1.C35 ; v1(80.94,73.85) 80.71,73.62 80.71,73.1 CA20.1
  IN3 w0.109: v1(80.94,73.85) 80.71,74.08 80.71,74.78 79.63,75.86 79.63,80.37 78.51,81.48 78.51,100.58 79.78,101.85 79.78,108.56 81.41,110.19 81.41,117.98 81.03,118.36 81.03,119 82.04,120.02 82.04,120.65 82.38,120.99 82.38,121.36 v3(82.52,121.5)
UPHY0_RX2_P: length 52.7
  TOP w0.102: v3(81.98,121.5) 82.14,121.34 82.14,121.02 81.99,120.86 J1.C34 ; v1(80.23,73.85) 80.45,73.62 80.45,73.1 CA21.1
  IN3 w0.109: v3(81.98,121.5) 82.12,121.36 82.12,121.09 81.79,120.76 81.79,120.12 80.77,119.1 80.77,118.26 81.15,117.88 81.15,110.29 79.53,108.67 79.53,101.96 78.26,100.69 78.26,81.38 79.38,80.26 79.38,75.76 80.45,74.68 80.45,74.08 v1(80.23,73.85)
UPHY0_RX3_N: length 75.6
  TOP w0.114: v3(79.98,120) 80.12,119.86 80.12,119.54 79.93,119.36 J1.B32
  IN1 w0.122: v1(135.23,118.37) 135,118.6 135,118.85 134.65,119.2 133.86,119.2 133.5,118.85 133.5,117.55 133.27,117.32 131.72,117.32 130.24,118.81 127.52,118.81 123.04,114.33 84.48,114.33 80.92,117.89 80.92,118.54 81.71,119.33 81.71,120.27 81.31,120.68 80.38,120.68 80.11,120.4 80.11,120.12 v3(79.98,120)
  BOTTOM w0.114: RZ172.1 142.62,120.35 142.62,120.2 142.36,119.94 140.79,119.94 139.85,119 135.24,119 135,118.76 135,118.6 v1(135.23,118.37)
UPHY0_RX3_P: length 75.6
  TOP w0.114: J1.B33 80.51,119.36 80.37,119.5 80.37,119.85 v3(80.52,120)
  IN1 w0.122: v1(134.52,118.37) 134.75,118.6 134.75,118.74 134.54,118.95 133.96,118.95 133.76,118.74 133.76,117.45 133.38,117.07 133,117.07 132.87,116.94 132.49,116.94 132.36,117.07 131.62,117.07 131.35,117.34 131.17,117.34 130.9,117.61 130.9,117.79 130.13,118.56 127.63,118.56 126.99,117.92 126.99,117.73 126.72,117.46 126.53,117.46 126.26,117.19 126.26,117.01 126,116.74 125.81,116.74 125.54,116.47 125.54,116.29 125.27,116.02 125.09,116.02 123.14,114.07 84.38,114.07 82.84,115.61 82.66,115.61 82.39,115.88 82.39,116.07 82.12,116.33 81.93,116.33 81.66,116.6 81.66,116.79 80.67,117.78 80.67,118.64 81.46,119.43 81.46,120.16 81.2,120.42 80.49,120.42 80.37,120.3 80.37,120.15 v3(80.52,120)
  BOTTOM w0.114: v1(134.52,118.37) 134.75,118.6 134.75,118.86 135.14,119.25 139.75,119.25 140.69,120.19 142.25,120.19 142.37,120.31 142.37,120.35 RZ173.1
UPHY0_RX4_N: length 65.3
  TOP w0.114: v3(79.98,122.99) 80.04,122.94 arc(80.1,122.86) 80.12,122.76 80.12,122.58 arc(80.05,122.42) 79.89,122.36 J1.D32 ; v1(138.46,116.52) 138.57,116.63 arc(138.65,116.76) 138.68,116.92 138.68,117.42 arc(138.68,117.47) 138.65,117.51 138.61,117.55 arc(138.57,117.6) 138.56,117.66 SSD2.5
  BOTTOM w0.114: v3(79.98,122.99) 80.07,122.91 arc(80.11,122.85) 80.12,122.78 80.12,122.45 arc(80.14,122.32) 80.18,122.19 80.52,121.47 arc(80.59,121.36) 80.68,121.27 84.09,118.21 arc(84.15,118.16) 84.21,118.12 85.43,117.29 arc(85.5,117.24) 85.57,117.21 86.72,116.72 arc(87.46,116.47) 88.22,116.3 91.25,115.85 arc(91.89,115.77) 92.54,115.75 100.69,115.75 116.19,116.2 arc(116.2,116.2) 116.2,116.2 127.41,115.55 arc(127.47,115.55) 127.52,115.54 133.95,115.54 arc(134.31,115.57) 134.66,115.66 136.87,116.37 arc(137.03,116.44) 137.18,116.54 137.54,116.85 arc(137.69,116.94) 137.86,116.97 138.57,116.97 arc(138.65,116.93) 138.68,116.85 138.68,116.75 arc(138.62,116.59) v1(138.46,116.52)
UPHY0_RX4_P: length 65.4
  TOP w0.114: SSD2.7 139.06,117.64 arc(139.05,117.58) 139.01,117.53 138.98,117.49 arc(138.95,117.45) 138.94,117.4 138.94,116.92 arc(138.97,116.76) 139.06,116.63 v1(139.17,116.52) ; v3(80.52,122.99) 80.43,122.91 arc(80.39,122.84) 80.37,122.76 80.37,122.58 arc(80.43,122.42) 80.59,122.36 J1.D33
  BOTTOM w0.114: v3(80.52,122.99) 80.43,122.91 arc(80.39,122.85) 80.38,122.78 80.38,122.45 arc(80.39,122.37) 80.41,122.3 80.75,121.58 arc(80.79,121.52) 80.85,121.46 84.26,118.4 arc(84.31,118.36) 84.35,118.33 85.57,117.5 arc(85.62,117.47) 85.67,117.44 86.82,116.96 arc(87.52,116.71) 88.26,116.55 91.29,116.1 arc(91.91,116.03) 92.54,116 100.68,116 116.18,116.45 arc(116.2,116.45) 116.22,116.45 116.22,116.45 127.42,115.8 arc(127.47,115.8) 127.52,115.8 133.95,115.8 arc(134.27,115.82) 134.58,115.9 136.79,116.61 arc(136.91,116.66) 137.01,116.73 137.37,117.04 arc(137.6,117.17) 137.86,117.22 138.57,117.22 arc(138.83,117.11) 138.94,116.85 138.94,116.75 arc(139.01,116.59) v1(139.17,116.52)
UPHY0_RX5_N: length 64.7
  TOP w0.114: v3(82.52,118.5) 82.44,118.42 arc(82.39,118.35) 82.37,118.26 82.37,118.06 arc(82.43,117.92) 82.57,117.86 J1.A35 ; v1(141.46,116.78) 141.6,116.92 arc(141.66,117.01) 141.68,117.12 141.68,117.45 arc(141.68,117.49) 141.65,117.53 141.6,117.58 arc(141.57,117.62) 141.56,117.68 SSD2.17
  BOTTOM w0.114: v3(82.52,118.5) 82.43,118.4 arc(82.39,118.35) 82.38,118.29 82.38,118.06 arc(82.4,117.96) 82.48,117.88 83.27,117.41 83.46,117.46 83.77,117.28 83.82,117.09 84.12,116.91 84.31,116.96 84.62,116.78 84.67,116.59 85.91,115.86 arc(86.04,115.8) 86.17,115.77 91.42,115.05 arc(92.05,114.99) 92.69,114.96 108.81,114.82 108.95,114.96 109.3,114.95 109.44,114.82 109.79,114.81 109.93,114.95 110.29,114.94 110.42,114.81 114.45,114.77 119.12,114.77 119.25,114.91 119.61,114.91 119.75,114.77 134.5,114.77 arc(134.71,114.78) 134.92,114.82 136.98,115.25 137.09,115.41 137.43,115.49 137.6,115.38 137.94,115.45 138.05,115.62 138.4,115.69 138.56,115.58 141.48,116.2 arc(141.56,116.23) 141.63,116.28 arc(141.67,116.35) 141.68,116.42 141.68,116.55 arc(141.62,116.71) v1(141.46,116.78)
UPHY0_RX5_P: length 64.7
  TOP w0.114: v1(142.17,116.78) 142.02,116.92 arc(141.96,117.01) 141.94,117.12 141.94,117.45 arc(141.95,117.5) 141.98,117.54 142.01,117.58 arc(142.05,117.63) 142.06,117.7 SSD2.19 ; J1.A34 81.92,117.86 arc(82.06,117.92) 82.12,118.06 82.12,118.26 arc(82.1,118.35) 82.05,118.43 v3(81.98,118.5)
  BOTTOM w0.114: v3(81.98,118.5) 82.08,118.4 arc(82.11,118.35) 82.12,118.29 82.12,118.06 arc(82.18,117.83) 82.35,117.66 85.78,115.64 arc(85.95,115.56) 86.14,115.52 91.38,114.8 arc(92.04,114.73) 92.69,114.71 114.45,114.52 134.5,114.52 arc(134.74,114.53) 134.98,114.57 141.53,115.95 arc(141.68,116.01) 141.81,116.1 arc(141.9,116.25) 141.94,116.42 141.94,116.55 arc(142.01,116.71) v1(142.17,116.78)
UPHY0_SF_PCIE1_CLK_N: length 61.3
  TOP w0.114: v3(95.18,122.99) 95.33,122.85 95.33,122.49 95.2,122.36 J1.D48
  IN1 w0.122: v1(144.34,125.03) 144.11,124.8 144.11,123.99 143.49,123.37 135.32,123.37 133.4,121.44 126.99,121.44 122.4,116.86 96.2,116.86 95.55,117.5 95.55,121.74 95.32,121.97 95.32,122.86 v3(95.18,122.99)
  BOTTOM w0.114: WIFI1.49 144.24,124.02 144.11,124.14 144.11,124.8 v1(144.34,125.03)
UPHY0_SF_PCIE1_CLK_P: length 61.3
  TOP w0.114: v3(95.72,122.99) 95.58,122.86 95.58,122.49 95.71,122.36 J1.D49
  IN1 w0.122: v3(95.72,122.99) 95.58,122.86 95.58,122.08 95.81,121.84 95.81,117.6 96.3,117.11 99.97,117.11 100.1,117.24 100.46,117.24 100.59,117.11 100.96,117.11 101.09,117.24 101.45,117.24 101.58,117.11 101.95,117.11 102.08,117.24 102.44,117.24 102.57,117.11 122.3,117.11 122.57,117.38 122.57,117.56 122.84,117.83 123.02,117.83 123.29,118.1 123.29,118.28 123.56,118.55 123.74,118.55 126.89,121.7 133.29,121.7 135.22,123.62 138.98,123.62 139.11,123.75 139.48,123.75 139.61,123.62 139.97,123.62 140.1,123.75 140.47,123.75 140.6,123.62 140.96,123.62 141.09,123.75 141.46,123.75 141.59,123.62 143.38,123.62 143.86,124.1 143.86,124.8 v1(143.63,125.03)
  BOTTOM w0.114: WIFI1.47 143.74,124.02 143.86,124.14 143.86,124.8 v1(143.63,125.03)
UPHY0_TX2_N: length 64.9
  TOP w0.102: J1.K33 80.48,131.36 80.36,131.47 80.36,131.86 v3(80.5,132) ; v1(79.03,74.49) 78.8,74.26 78.8,73.1 CA23.1
  IN3 w0.109: v3(80.5,132) 80.5,131.92 80.35,131.77 80.35,131.47 80.07,131.19 79.12,131.19 78.36,130.43 78.36,118.6 79.1,117.86 79.86,117.86 80.26,117.45 80.26,111.91 77.24,108.89 77.24,99.55 77.62,99.17 77.62,80.95 78.8,79.77 78.8,74.71 v1(79.03,74.49)
UPHY0_TX2_P: length 64.9
  TOP w0.102: CA24.1 78.55,73.1 78.55,74.26 v1(78.32,74.49) ; v3(79.97,132) 80.11,131.85 80.11,131.47 79.99,131.36 J1.K32
  IN3 w0.109: v1(78.32,74.49) 78.55,74.71 78.55,79.66 77.37,80.84 77.37,99.06 76.99,99.44 76.99,108.99 80.01,112.01 80.01,117.35 79.76,117.6 78.99,117.6 78.11,118.49 78.11,130.53 79.02,131.44 79.97,131.44 80.09,131.57 80.09,131.77 80.04,131.82 80.04,131.92 v3(79.97,132)
UPHY0_TX3_N: length 75.5
  TOP w0.114: v3(81.98,127.5) 82.12,127.36 82.12,126.99 81.99,126.86 J1.G34
  IN1 w0.122: v1(132.82,118.34) 132.59,118.57 132.59,119.56 131.76,120.38 127.43,120.38 122.21,115.16 87.33,115.16 84.1,118.39 84.1,118.65 83.06,119.69 83.06,120.19 83.97,121.11 83.97,121.81 84.71,122.55 84.71,126.83 83.39,128.14 82.44,128.14 82.17,127.87 82.17,127.68 v3(81.98,127.5)
  BOTTOM w0.114: CM66.1 138.53,120.36 138.53,120.21 138.32,120 134.83,120 133.62,118.8 132.7,118.8 132.59,118.68 132.59,118.57 v1(132.82,118.34)
UPHY0_TX3_P: length 75.5
  TOP w0.114: v3(82.52,127.5) 82.37,127.35 82.37,126.97 82.49,126.86 J1.G35
  IN1 w0.122: v1(132.11,118.34) 132.33,118.57 132.33,119.45 131.66,120.13 127.54,120.13 125.21,117.81 125.21,117.63 124.94,117.36 124.76,117.36 124.49,117.09 124.49,116.9 124.22,116.63 124.04,116.63 122.32,114.91 87.22,114.91 85.7,116.44 85.51,116.44 85.24,116.71 85.24,116.89 84.97,117.16 84.79,117.16 84.52,117.43 84.52,117.61 83.85,118.29 83.85,118.54 82.8,119.58 82.8,120.3 83.72,121.21 83.72,121.92 84.45,122.66 84.45,123.6 84.33,123.73 84.33,124.11 84.45,124.24 84.45,124.62 84.33,124.75 84.33,125.13 84.45,125.26 84.45,125.64 84.33,125.77 84.33,126.15 84.45,126.28 84.45,126.72 84.11,127.07 83.93,127.07 83.66,127.34 83.66,127.52 83.29,127.89 82.54,127.89 82.42,127.77 82.42,127.59 v3(82.52,127.5)
  BOTTOM w0.114: v1(132.11,118.34) 132.33,118.57 132.33,118.79 132.6,119.05 133.51,119.05 134.72,120.26 138.21,120.26 138.28,120.32 138.28,120.41 CM67.1
UPHY0_TX4_N: length 72.6
  TOP w0.114: 87.66,113.46 87.79,113.32 arc(87.86,113.22) 87.88,113.11 87.88,112.75 arc(87.93,112.54) 88.07,112.37 88.39,112.12 arc(88.78,111.92) 89.21,111.85 96.63,111.87 arc(96.69,111.87) 96.75,111.87 115.17,111.53 arc(115.97,111.58) 116.75,111.75 122.17,113.39 arc(122.89,113.69) 123.54,114.14 127.41,117.46 arc(127.71,117.66) 128.05,117.77 129.48,118.03 129.48,118.03 arc(130.13,118.19) 130.75,118.43 135.73,120.75 arc(135.97,120.83) 136.22,120.86 136.81,120.86 arc(137.12,120.73) CM25.1 ; 81.95,130.5 81.98,130.47 arc(82.06,130.34) 82.09,130.2 82.09,130.1 arc(82.02,129.93) 81.85,129.86 J1.J34
  IN3 w0.122: 87.66,113.46 87.78,113.58 arc(87.86,113.7) 87.88,113.84 87.88,114.44 arc(87.88,114.5) 87.87,114.56 85.98,120.77 arc(85.96,120.83) 85.93,120.88 84.67,122.71 arc(84.63,122.77) 84.59,122.84 83.98,123.98 arc(83.94,124.08) 83.92,124.18 83.5,127.36 arc(83.49,127.42) 83.48,127.48 83.38,127.78 arc(83.36,127.84) 83.32,127.89 82.47,128.86 arc(82.43,128.91) 82.4,128.96 82.14,129.51 arc(82.11,129.62) 82.09,129.74 82.09,130.16 arc(82.06,130.34) 81.95,130.5
UPHY0_TX4_N_M2M: length 4.4
  TOP w0.114: SSD2.11 140.06,119.03 arc(140.07,119.08) 140.1,119.11 140.15,119.17 arc(140.18,119.21) 140.18,119.25 140.18,119.58 arc(140.15,119.75) 140.06,119.89 139.01,120.94 arc(138.96,120.97) 138.9,120.98 138.38,120.98 arc(138.24,120.92) 138.19,120.79 CM25.2
UPHY0_TX4_P: length 72.6
  TOP w0.114: 88.37,113.46 88.23,113.32 arc(88.16,113.22) 88.14,113.11 88.14,112.75 arc(88.16,112.65) 88.23,112.57 88.55,112.32 arc(88.86,112.16) 89.21,112.1 90.46,112.1 90.6,112.24 90.96,112.24 91.09,112.11 91.45,112.11 91.59,112.24 91.94,112.25 92.08,112.11 96.63,112.12 arc(96.69,112.12) 96.75,112.12 98.16,112.1 98.3,112.23 98.66,112.23 98.79,112.09 115.17,111.78 arc(115.93,111.83) 116.67,111.99 122.1,113.63 arc(122.77,113.92) 123.37,114.33 127.24,117.66 arc(127.6,117.89) 128,118.02 129.44,118.28 arc(130.05,118.43) 130.64,118.66 135.62,120.98 arc(135.91,121.08) 136.22,121.12 136.8,121.12 arc(137.12,121.25) CM26.1 ; 82.49,130.5 82.46,130.47 arc(82.38,130.34) 82.35,130.2 82.35,130.1 arc(82.42,129.93) 82.59,129.86 J1.J35
  IN3 w0.122: 88.37,113.46 88.25,113.58 arc(88.17,113.7) 88.14,113.84 88.14,114.44 arc(88.13,114.54) 88.11,114.63 86.22,120.85 arc(86.19,120.94) 86.14,121.03 84.88,122.85 arc(84.85,122.9) 84.82,122.96 84.21,124.1 arc(84.19,124.15) 84.17,124.21 83.75,127.4 arc(83.74,127.48) 83.72,127.56 83.63,127.86 arc(83.58,127.96) 83.52,128.06 82.66,129.03 arc(82.65,129.05) 82.63,129.07 82.37,129.62 arc(82.35,129.68) 82.35,129.74 82.35,130.16 arc(82.38,130.34) 82.49,130.5
UPHY0_TX4_P_M2M: length 4.4
  TOP w0.114: SSD2.13 140.56,119.03 arc(140.55,119.07) 140.53,119.11 140.47,119.17 arc(140.45,119.2) 140.44,119.25 140.44,119.58 arc(140.39,119.84) 140.24,120.07 139.19,121.12 arc(139.06,121.2) 138.9,121.23 138.6,121.23 arc(138.53,121.25) 138.46,121.29 CM26.2
UPHY0_TX5_N: length 78
  TOP w0.114: 80.52,128.99 80.46,128.94 arc(80.4,128.85) 80.38,128.76 80.38,128.58 arc(80.45,128.42) 80.6,128.36 J1.H33 ; CM27.1 arc(141.56,120.72) 141.24,120.85 141.04,120.85 arc(140.91,120.87) 140.79,120.93 138.99,122.17 arc(138.94,122.2) 138.89,122.23 138.5,122.39 arc(138.44,122.4) 138.39,122.41 136.91,122.41 136.31,122.39 arc(135.87,122.33) 135.46,122.16 130.42,119.44 arc(129.99,119.25) 129.53,119.14 127.99,118.89 arc(127.36,118.7) 126.8,118.35 122.88,115.12 arc(122.04,114.56) 121.11,114.18 116.18,112.68 arc(115.67,112.57) 115.14,112.54 101.05,112.88 arc(100.23,112.92) 99.42,113.02 95.57,113.6 95.41,113.49 95.06,113.54 94.94,113.7 92.73,114.03 arc(92.67,114.04) 92.62,114.04 91.22,114.11 91.07,113.98 90.72,114 90.59,114.14 90.23,114.16 90.09,114.03 89.73,114.05 89.6,114.19 88.62,114.24 arc(88.57,114.24) 88.51,114.24 86.69,114.15 arc(86.55,114.08) 86.49,113.93 86.49,113.78 arc(86.56,113.62) 86.72,113.55
  IN3 w0.122: 80.52,128.99 80.45,128.93 arc(80.4,128.85) 80.38,128.75 80.38,128.31 arc(80.38,128.25) 80.39,128.19 80.87,126.32 arc(80.89,126.26) 80.91,126.21 82.42,122.98 arc(82.45,122.93) 82.49,122.88 82.63,122.68 arc(82.67,122.64) 82.71,122.6 83.88,121.83 arc(83.94,121.78) 84,121.74 85.31,120.59 arc(85.46,120.41) 85.53,120.2 86.45,115.41 arc(86.48,115.21) 86.49,115.01 86.49,113.94 arc(86.52,113.79) 86.6,113.66 86.72,113.55
UPHY0_TX5_N_M2M: length 3.7
  TOP w0.114: SSD2.23 143.06,119.06 arc(143.07,119.11) 143.1,119.14 143.15,119.2 arc(143.18,119.24) 143.18,119.28 143.18,120.87 arc(143.15,120.96) 143.06,121 142.77,121 arc(142.67,120.96) 142.63,120.87 CM27.2
UPHY0_TX5_P: length 78
  TOP w0.114: J1.H32 79.91,128.36 arc(80.07,128.42) 80.13,128.58 80.13,128.76 arc(80.11,128.84) 80.07,128.91 79.98,128.99 ; 86,113.55 arc(86.17,113.62) 86.23,113.78 86.23,113.93 arc(86.36,114.26) 86.68,114.4 88.5,114.5 88.55,114.5 88.57,114.5 88.57,114.5 92.63,114.3 arc(92.7,114.29) 92.77,114.28 99.46,113.27 arc(100.26,113.17) 101.05,113.13 115.15,112.8 arc(115.63,112.82) 116.1,112.93 121.03,114.42 arc(121.92,114.79) 122.72,115.32 126.64,118.54 arc(127.26,118.93) 127.95,119.14 129.49,119.39 arc(129.91,119.49) 130.3,119.66 135.34,122.39 arc(135.8,122.57) 136.3,122.65 136.9,122.66 138.39,122.66 arc(138.49,122.65) 138.59,122.62 138.99,122.46 arc(139.06,122.43) 139.12,122.39 140.93,121.14 arc(140.98,121.12) 141.04,121.11 141.26,121.11 arc(141.57,121.23) CM28.1
  IN3 w0.122: 79.98,128.99 80.05,128.93 arc(80.1,128.85) 80.12,128.75 80.12,128.31 arc(80.13,128.21) 80.15,128.12 80.63,126.26 arc(80.65,126.18) 80.68,126.1 82.19,122.87 arc(82.23,122.8) 82.28,122.73 82.42,122.53 arc(82.49,122.45) 82.57,122.39 83.74,121.62 arc(83.79,121.58) 83.83,121.54 85.14,120.4 arc(85.23,120.29) 85.28,120.15 86.2,115.36 arc(86.22,115.19) 86.23,115.01 86.23,113.94 arc(86.2,113.79) 86.12,113.66 86,113.55
UPHY0_TX5_P_M2M: length 3.7
  TOP w0.114: SSD2.25 143.56,119.08 arc(143.55,119.12) 143.53,119.16 143.47,119.21 arc(143.45,119.25) 143.44,119.29 143.44,120.87 arc(143.33,121.14) 143.06,121.25 143,121.25 arc(142.93,121.27) 142.86,121.31 CM28.2
UPHY0_TX6_N_M2M: length 3
  TOP w0.114: CM29.2 146.53,120.82 arc(146.67,120.76) 146.72,120.62 146.72,120.45 arc(146.71,120.33) 146.66,120.22 146.24,119.52 arc(146.2,119.43) 146.18,119.33 146.18,119.21 arc(146.18,119.16) 146.15,119.13 146.1,119.07 arc(146.07,119.03) 146.06,118.99 SSD2.35
UPHY0_TX6_P_M2M: length 3
  TOP w0.114: SSD2.37 146.56,119 arc(146.55,119.04) 146.53,119.08 146.47,119.14 arc(146.45,119.17) 146.44,119.22 146.44,119.33 arc(146.44,119.36) 146.46,119.39 146.88,120.09 arc(146.95,120.26) 146.98,120.45 146.98,120.64 arc(147.03,120.76) 147.15,120.82 CM1.2
UPHY0_TX7_N_M2M: length 4.2
  TOP w0.114: SSD2.47 149.06,118.99 arc(149.07,119.04) 149.1,119.07 149.15,119.13 arc(149.18,119.17) 149.18,119.21 149.18,119.55 arc(149.34,119.97) 149.74,120.16 150.76,120.26 arc(150.82,120.27) 150.87,120.28 arc(150.92,120.33) 150.94,120.39 150.94,120.62 arc(150.88,120.76) 150.75,120.82 CM30.2
UPHY0_TX7_P_M2M: length 4.2
  TOP w0.114: SSD2.49 149.56,119 arc(149.55,119.04) 149.53,119.08 149.47,119.13 arc(149.45,119.17) 149.44,119.21 149.44,119.55 arc(149.53,119.79) 149.76,119.91 150.78,120 arc(150.88,120.02) 150.96,120.05 arc(151.13,120.18) 151.19,120.39 151.19,120.62 arc(151.25,120.76) 151.38,120.82 CM31.2
UPHY1_RX0_N: length 28.7
  TOP w0.114: v3(72.52,122.99) 72.39,122.87 72.39,122.53 72.56,122.36 J1.D25 ; CM41.2 55.75,109.91 55.75,110.32 v1(55.98,110.55)
  IN3 w0.122: v3(72.52,122.99) 72.38,122.86 72.38,121.08 71.91,120.61 71.27,120.61 70.97,120.31 70.97,119.71 71.7,118.97 71.7,117.7 71.32,117.32 68.86,117.32 65.28,113.74 62.89,113.74 61.88,112.73 58.78,112.73 58.47,112.42 56.06,112.42 55.75,112.12 55.75,110.78 v1(55.98,110.55)
UPHY1_RX0_P: length 28.7
  TOP w0.114: v1(55.27,110.55) 55.5,110.32 55.5,109.91 CM40.2 ; J1.D24 71.97,122.36 72.14,122.53 72.14,122.84 v3(71.98,122.99)
  IN3 w0.122: v3(71.98,122.99) 72.12,122.86 72.12,121.19 71.8,120.87 71.17,120.87 70.71,120.42 70.71,119.6 71.45,118.87 71.45,117.81 71.22,117.58 68.76,117.58 65.18,114 62.79,114 61.77,112.98 58.67,112.98 58.37,112.67 55.95,112.67 55.5,112.22 55.5,110.78 v1(55.27,110.55)
UPHY1_RX1_N: length 24.2
  TOP w0.114: J1.B24 71.96,119.36 72.11,119.51 72.11,119.87 v3(71.98,120)
  IN3 w0.122: v1(58.39,110.81) 58.17,110.58 58.17,110.46 58.29,110.34 58.87,110.34 59.18,110.65 59.18,111.64 59.61,112.06 60,112.06 60.13,112.19 60.52,112.19 60.65,112.06 62.02,112.06 62.86,112.9 63.17,112.9 63.3,113.03 63.68,113.03 63.81,112.9 64.19,112.9 64.32,113.03 64.7,113.03 64.83,112.9 65.6,112.9 65.77,113.07 65.77,113.26 66.04,113.53 66.23,113.53 66.5,113.79 66.5,113.98 66.77,114.25 66.95,114.25 67.22,114.52 67.22,114.7 67.49,114.97 67.67,114.97 69.31,116.61 70.09,116.61 70.22,116.74 70.6,116.74 70.73,116.61 71.37,116.61 72.47,117.71 72.47,118.13 72.34,118.26 72.34,118.65 72.47,118.77 72.47,119.16 72.12,119.5 72.12,119.86 v3(71.98,120)
  BOTTOM w0.114: v1(58.39,110.81) 58.17,110.58 58.17,109.94 CM68.2
UPHY1_RX1_P: length 24.2
  TOP w0.114: v3(72.52,120) 72.36,119.84 72.36,119.51 72.51,119.36 J1.B25
  IN3 w0.122: v1(57.68,110.81) 57.91,110.58 57.91,110.35 58.18,110.08 58.98,110.08 59.44,110.54 59.44,111.53 59.72,111.81 62.13,111.81 62.97,112.65 65.71,112.65 69.42,116.36 71.48,116.36 72.72,117.6 72.72,119.26 72.38,119.6 72.38,119.86 v3(72.52,120)
  BOTTOM w0.114: CM69.2 57.91,109.94 57.91,110.58 v1(57.68,110.81)
UPHY1_RX2_N: length 26.5
  TOP w0.114: J1.C26 74,120.86 74.12,120.98 74.12,121.36 v3(73.98,121.5) ; v1(60.81,110.81) 60.58,110.58 60.58,109.78 CM43.2
  IN3 w0.122: v1(60.81,110.81) 60.74,110.81 60.55,110.62 60.55,110.41 60.68,110.29 61.11,110.29 61.24,110.42 61.62,110.42 61.75,110.29 63.84,110.29 63.97,110.42 64.35,110.42 64.48,110.29 65.4,110.29 65.52,110.41 65.52,110.59 65.79,110.86 65.97,110.86 66.24,111.13 66.24,111.31 66.51,111.58 66.69,111.58 70,114.88 70.65,114.88 70.78,115.01 71.16,115.01 71.29,114.88 72.06,114.88 73.02,115.84 73.02,116.02 73.29,116.29 73.47,116.29 73.74,116.56 73.74,116.75 74.01,117.02 74.19,117.02 75.06,117.88 75.26,117.88 75.56,118.19 75.56,118.87 75.31,119.13 74.72,119.13 74.15,119.7 74.15,121.33 v3(73.98,121.5)
UPHY1_RX2_P: length 26.6
  TOP w0.114: CM42.2 60.33,109.78 60.33,110.58 v1(60.1,110.81) ; J1.C27 74.49,120.86 74.37,120.98 74.37,121.35 v3(74.52,121.5)
  IN3 w0.122: v3(74.52,121.5) 74.4,121.38 74.4,119.81 74.83,119.38 75.42,119.38 75.82,118.98 75.82,118.08 75.37,117.63 75.16,117.63 72.17,114.63 70.1,114.63 65.78,110.3 65.77,110.3 65.5,110.03 60.57,110.03 60.3,110.3 60.3,110.6 v1(60.1,110.81)
UPHY1_RX3_N: length 17.8
  TOP w0.114: J1.A27 74.61,117.86 74.37,118.11 74.37,118.35 v3(74.52,118.5)
  IN3 w0.122: v3(74.52,118.5) 74.37,118.35 74.37,118.14 71.81,115.57 69.75,115.57 66.01,111.84 63.3,111.84 62.99,111.53 62.99,111 v1(63.22,110.77)
  BOTTOM w0.114: v1(63.22,110.77) 62.99,110.54 62.99,109.91 CM70.2
UPHY1_RX3_P: length 17.8
  TOP w0.114: 73.92,117.86 74.12,118.06 74.12,118.36 v3(73.98,118.5)
  TOP w0.127: J1.A26 73.92,117.86
  IN3 w0.122: v3(73.98,118.5) 74.12,118.36 74.12,118.24 71.7,115.82 69.64,115.82 65.91,112.09 63.2,112.09 62.74,111.63 62.74,111 v1(62.51,110.77)
  BOTTOM w0.114: v1(62.51,110.77) 62.74,110.54 62.74,109.91 CM71.2
UPHY1_TX0_N: length 30.9
  TOP w0.114: J1.H25 72.5,128.36 72.39,128.47 72.39,128.87 v3(72.52,128.99) ; v1(54.71,114.06) 54.48,113.83 54.48,113.41 CM33.2
  IN3 w0.122: v1(54.71,114.06) 54.48,114.29 54.48,115.37 56.82,117.7 62,117.7 64.34,120.04 64.34,125.86 65.23,126.75 66.17,126.75 67.63,128.21 72,128.21 72.39,128.6 72.39,128.87 v3(72.52,128.99)
UPHY1_TX0_P: length 30.9
  TOP w0.114: v3(71.98,128.99) 72.14,128.84 72.14,128.47 72.02,128.36 J1.H24 ; v1(54,114.06) 54.23,113.83 54.23,113.41 CM32.2
  IN3 w0.122: v1(54,114.06) 54.23,114.29 54.23,115.47 56.71,117.96 61.9,117.96 64.08,120.15 64.08,125.96 65.12,127 66.06,127 67.52,128.46 71.89,128.46 72.14,128.71 72.14,128.84 v3(71.98,128.99)
UPHY1_TX1_N: length 34.1
  TOP w0.114: J1.K24 71.97,131.36 72.14,131.52 72.14,131.84 v3(71.98,132) ; v1(57.19,114.06) 56.96,113.83 56.96,113.41 CM35.2
  IN3 w0.122: v1(57.19,114.06) 56.96,113.83 56.96,113.76 57.08,113.64 57.74,113.64 57.91,113.81 57.91,115.04 58.18,115.31 58.18,115.49 58.45,115.76 58.63,115.76 58.9,116.03 58.9,116.22 59.17,116.48 59.36,116.48 59.91,117.04 60.92,117.04 61.05,117.17 61.43,117.17 61.56,117.04 61.94,117.04 62.07,117.17 62.45,117.17 62.58,117.04 64.11,117.04 64.37,117.31 64.37,117.5 64.64,117.77 64.83,117.77 66.04,118.98 66.04,120.81 65.91,120.94 65.91,121.32 66.04,121.45 66.04,121.83 65.91,121.96 65.91,122.34 66.04,122.47 66.04,124.46 67.06,125.48 67.82,125.48 69.14,126.8 71.6,126.8 72.15,127.35 72.15,127.53 72.42,127.8 72.6,127.8 73.46,128.65 73.46,129.38 72.12,130.72 72.12,131.86 v3(71.98,132)
UPHY1_TX1_P: length 34.1
  TOP w0.114: v3(72.52,132) 72.39,131.87 72.39,131.52 72.55,131.36 J1.K25 ; v1(56.48,114.06) 56.71,113.83 56.71,113.41 CM34.2
  IN3 w0.122: v1(56.48,114.06) 56.71,113.83 56.71,113.66 56.98,113.39 57.84,113.39 58.17,113.71 58.17,114.94 60.02,116.79 64.21,116.79 66.29,118.87 66.29,124.35 67.16,125.22 67.92,125.22 69.24,126.54 71.7,126.54 73.71,128.55 73.71,129.49 72.38,130.82 72.38,131.86 v3(72.52,132)
UPHY1_TX2_N: length 28.3
  TOP w0.114: CM37.2 59.37,113.41 59.37,114.03 v1(59.6,114.26) ; J1.G26 73.98,126.86 74.12,127 74.12,127.36 v3(73.98,127.5)
  IN3 w0.122: v3(73.98,127.5) 74.12,127.36 74.12,126.36 73.1,125.35 72.72,125.35 72.59,125.48 72.21,125.48 72.08,125.35 71.7,125.35 71.57,125.48 71.19,125.48 71.06,125.35 69.24,125.35 68.07,124.18 68.07,123.56 67.94,123.43 67.94,123.05 68.07,122.92 68.07,122.54 67.94,122.41 67.94,122.03 68.07,121.9 68.07,121.26 67.46,120.65 67.46,119.61 66.93,119.07 66.93,118.24 66.66,117.97 66.48,117.97 66.21,117.7 66.21,117.52 65.94,117.25 65.75,117.25 65.48,116.98 65.48,116.8 64.81,116.12 63.79,116.12 63.67,116.25 63.28,116.25 63.15,116.12 62.77,116.12 62.64,116.25 62.26,116.25 62.13,116.12 61.38,116.12 60.35,115.09 60.35,114.1 60.02,113.77 59.49,113.77 59.37,113.89 59.37,114.03 v1(59.6,114.26)
UPHY1_TX2_P: length 28.3
  TOP w0.114: v3(74.52,127.5) 74.37,127.35 74.37,127.01 74.52,126.86 J1.G27 ; CM36.2 59.12,113.41 59.12,114.03 v1(58.89,114.26)
  IN3 w0.122: v1(58.89,114.26) 59.12,114.03 59.12,113.78 59.39,113.51 60.12,113.51 60.6,114 60.6,114.99 61.49,115.87 64.92,115.87 67.18,118.14 67.18,118.97 67.72,119.5 67.72,120.55 68.33,121.16 68.33,124.08 69.34,125.09 73.21,125.09 74.37,126.26 74.37,127.35 v3(74.52,127.5)
UPHY1_TX3_N: length 29
  TOP w0.114: v3(74.52,130.5) 74.37,130.35 74.37,129.97 74.48,129.86 J1.J27 ; CM39.2 61.85,113.41 61.85,113.83 v1(62.08,114.06)
  IN3 w0.122: v1(62.08,114.06) 61.85,114.29 61.85,114.83 62.11,115.09 65.36,115.09 68.99,118.72 68.99,120.24 70.59,121.83 70.59,123.31 71,123.72 73.66,123.72 75.82,125.88 75.82,129.31 75.37,129.76 74.76,129.76 74.38,130.15 74.38,130.36 v3(74.52,130.5)
UPHY1_TX3_P: length 29
  TOP w0.114: v1(61.37,114.06) 61.59,113.83 61.59,113.41 CM38.2 ; J1.J26 74,129.86 74.11,129.97 74.11,130.36 v3(73.98,130.5)
  IN3 w0.122: v3(73.98,130.5) 74.12,130.36 74.12,130.04 74.66,129.51 75.26,129.51 75.56,129.21 75.56,125.98 73.56,123.98 70.89,123.98 70.33,123.42 70.33,121.94 68.74,120.34 68.74,118.83 65.25,115.34 62,115.34 61.59,114.93 61.59,114.29 v1(61.37,114.06)
UPHY_RX0_N: length 130.9
  TOP w0.102: v3(70.52,118.5) 70.36,118.34 70.36,117.98 70.48,117.86 J1.A23
  IN1 w0.109: v1(158.66,182.33) 158.43,182.56 158.14,182.56 158.01,182.44 158.01,181.12 157.42,180.53 157.42,180.34 157.15,180.07 156.96,180.07 156.69,179.8 156.69,179.62 156.42,179.35 156.24,179.35 155.73,178.84 155.73,178.22 155.86,178.09 155.86,177.71 155.73,177.58 155.73,177.2 155.86,177.07 155.86,176.69 155.73,176.56 155.73,174.95 151.27,170.49 133.08,170.49 126.44,163.85 126.44,162.74 121.05,157.35 113.86,157.35 110.53,154.02 107.59,154.02 93.15,139.57 77.7,139.57 72.85,134.72 72.85,133.23 73.76,132.31 73.76,131.5 72.82,130.56 72.44,130.56 70.99,129.11 70.99,125.63 71.7,124.92 71.7,123.93 70.38,122.6 70.38,118.63 v3(70.52,118.5)
  BOTTOM w0.102: RZ143.1 157.96,182.45 158.08,182.56 158.43,182.56 v1(158.66,182.33)
UPHY_RX0_P: length 130.8
  TOP w0.102: v3(69.98,118.5) 70.1,118.37 70.1,117.98 69.98,117.86 J1.A22
  IN1 w0.109: v3(69.98,118.5) 70.12,118.63 70.12,122.71 71.45,124.03 71.45,124.81 70.74,125.52 70.74,129.21 72.34,130.81 72.72,130.81 73.51,131.6 73.51,132.21 72.59,133.12 72.59,134.82 77.6,139.83 93.04,139.83 107.49,154.27 110.42,154.27 113.76,157.61 120.95,157.61 126.19,162.85 126.19,163.95 132.98,170.74 151.16,170.74 155.47,175.06 155.47,178.94 157.76,181.23 157.76,182.55 158.03,182.82 158.43,182.82 v1(158.66,183.05)
  BOTTOM w0.102: v1(158.66,183.05) 158.43,182.82 158.08,182.82 157.96,182.93 RZ142.1
UPHY_RX10_N: length 90.9
  TOP w0.114: J1.B13 60.6,119.36 arc(60.44,119.43) 60.38,119.58 60.38,119.74 arc(60.4,119.84) 60.46,119.94 v3(60.52,120) ; v1(144.46,116.78) 144.6,116.92 arc(144.66,117.01) 144.68,117.12 144.68,117.4 arc(144.67,117.46) 144.64,117.52 144.6,117.55 arc(144.57,117.6) 144.56,117.65 SSD2.29
  BOTTOM w0.114: v3(60.52,120) 60.44,119.92 arc(60.39,119.85) 60.38,119.76 60.38,119.67 arc(60.41,119.6) 60.48,119.56 61.92,119.47 62.07,119.59 62.42,119.57 62.55,119.42 62.9,119.4 63.05,119.53 63.4,119.51 63.53,119.36 65.06,119.26 arc(65.18,119.24) 65.28,119.19 65.82,118.88 66.01,118.93 66.32,118.75 66.37,118.57 66.99,118.2 arc(67.04,118.18) 67.1,118.16 73.9,116.44 arc(74.45,116.33) 75,116.28 77.24,116.18 arc(77.29,116.18) 77.35,116.18 78.06,116.22 arc(78.13,116.23) 78.2,116.22 82.51,115.84 arc(82.57,115.83) 82.64,115.82 83.77,115.62 arc(84,115.55) 84.21,115.44 85.1,114.86 arc(85.5,114.67) 85.93,114.57 92.75,113.77 arc(92.8,113.77) 92.86,113.77 133.46,113.77 arc(133.99,113.71) 134.5,113.54 134.86,113.37 135.04,113.44 135.36,113.29 135.43,113.11 136.09,112.81 arc(136.32,112.73) 136.56,112.71 137.29,112.73 arc(137.35,112.74) 137.41,112.75 arc(137.48,112.79) 137.55,112.84 137.55,112.85 138.07,113.28 138.09,113.47 138.36,113.7 138.55,113.68 138.97,114.03 arc(139.25,114.22) 139.56,114.36 140.79,114.76 140.88,114.94 141.21,115.05 141.39,114.96 141.72,115.07 141.81,115.25 142.15,115.36 142.32,115.27 144.46,115.98 arc(144.62,116.1) 144.68,116.29 144.68,116.55 arc(144.62,116.71) v1(144.46,116.78)
UPHY_RX10_P: length 90.9
  TOP w0.114: J1.B12 59.9,119.36 arc(60.06,119.43) 60.12,119.58 60.12,119.74 arc(60.1,119.85) 60.04,119.94 v3(59.98,120) ; SSD2.31 145.06,117.65 arc(145.05,117.58) 145.01,117.53 144.98,117.5 arc(144.95,117.45) 144.94,117.4 144.94,117.12 arc(144.96,117.01) 145.02,116.92 v1(145.17,116.78)
  BOTTOM w0.114: v3(59.98,120) 60.06,119.92 arc(60.11,119.85) 60.12,119.76 60.12,119.67 arc(60.22,119.42) 60.47,119.31 65.05,119.01 arc(65.1,118.99) 65.16,118.97 66.86,117.98 arc(66.95,117.94) 67.03,117.91 73.84,116.2 arc(74.41,116.08) 74.99,116.03 77.23,115.93 arc(77.3,115.93) 77.36,115.93 78.08,115.97 arc(78.13,115.97) 78.18,115.97 82.48,115.59 arc(82.54,115.58) 82.6,115.57 83.72,115.37 arc(83.91,115.32) 84.08,115.23 84.97,114.65 arc(85.42,114.43) 85.9,114.31 92.72,113.52 arc(92.79,113.51) 92.86,113.51 133.46,113.51 arc(133.94,113.46) 134.39,113.31 135.98,112.58 arc(136.27,112.49) 136.57,112.46 137.3,112.48 arc(137.4,112.49) 137.5,112.52 arc(137.61,112.58) 137.72,112.65 139.13,113.84 arc(139.37,114) 139.64,114.12 144.54,115.73 arc(144.83,115.95) 144.94,116.29 144.94,116.55 arc(145.01,116.71) v1(145.17,116.78)
UPHY_RX11_N: length 99.6
  TOP w0.114: J1.D13 60.6,122.36 arc(60.45,122.42) 60.38,122.58 60.38,122.76 arc(60.4,122.85) 60.46,122.94 v3(60.52,123) ; SSD2.41 147.56,117.65 arc(147.57,117.6) 147.6,117.55 147.64,117.52 arc(147.67,117.46) 147.68,117.4 147.68,117.12 arc(147.66,117.01) 147.6,116.92 v1(147.46,116.78)
  BOTTOM w0.114: v3(60.52,123) 60.45,122.92 arc(60.4,122.85) 60.38,122.76 60.38,122.45 arc(60.37,122.34) 60.33,122.24 59.95,121.36 arc(59.91,121.27) 59.85,121.2 59.1,120.34 arc(59.07,120.29) 59.06,120.23 59.03,119.84 arc(59.04,119.79) 59.06,119.73 59.31,119.23 arc(59.34,119.18) 59.38,119.13 59.98,118.52 arc(60.01,118.49) 60.04,118.47 60.76,117.99 arc(60.81,117.96) 60.86,117.95 62.55,117.59 62.71,117.7 63.06,117.63 63.17,117.46 63.52,117.39 63.68,117.5 64.03,117.42 64.13,117.26 72.7,115.46 arc(73.46,115.33) 74.22,115.27 77.16,115.14 arc(77.2,115.14) 77.24,115.14 78.2,115.19 arc(78.28,115.2) 78.35,115.19 82.42,114.81 arc(82.49,114.81) 82.55,114.8 82.9,114.74 arc(83.01,114.71) 83.1,114.66 84.08,114.05 arc(84.15,114) 84.21,113.95 85.09,113.1 arc(85.23,112.98) 85.37,112.86 85.71,112.61 arc(85.78,112.57) 85.85,112.55 86.8,112.45 arc(86.84,112.45) 86.88,112.45 89.78,112.45 89.92,112.58 90.27,112.58 90.41,112.45 91.46,112.45 99.92,112.75 133.46,112.75 arc(133.67,112.73) 133.88,112.66 135.75,111.8 arc(136.07,111.7) 136.4,111.67 137.61,111.72 arc(137.98,111.8) 138.31,111.99 139.47,112.96 arc(139.7,113.12) 139.95,113.23 140.95,113.56 141.04,113.73 141.38,113.85 141.55,113.76 141.89,113.87 141.98,114.04 142.31,114.15 142.49,114.07 144.36,114.68 144.73,114.84 144.8,115.01 145.13,115.15 145.31,115.07 145.64,115.21 145.72,115.39 146.05,115.52 146.23,115.45 147.49,115.96 arc(147.63,116.08) 147.68,116.26 147.68,116.55 arc(147.62,116.71) v1(147.46,116.78)
UPHY_RX11_P: length 99.7
  TOP w0.114: J1.D12 59.91,122.36 arc(60.07,122.42) 60.13,122.58 60.13,122.76 arc(60.11,122.84) 60.07,122.91 v3(59.98,123) ; SSD2.43 148.06,117.65 arc(148.05,117.58) 148.01,117.53 147.98,117.5 arc(147.95,117.45) 147.94,117.4 147.94,117.12 arc(147.96,117.01) 148.02,116.92 v1(148.17,116.78)
  BOTTOM w0.114: v3(59.98,123) 60.05,122.92 arc(60.11,122.85) 60.12,122.76 60.12,122.45 arc(60.12,122.4) 60.1,122.34 59.72,121.46 arc(59.69,121.41) 59.66,121.36 58.91,120.5 arc(58.83,120.39) 58.8,120.25 58.78,119.86 arc(58.79,119.74) 58.83,119.62 59.09,119.12 arc(59.14,119.03) 59.2,118.96 59.8,118.34 arc(59.85,118.3) 59.9,118.26 arc(59.9,118.26) 59.9,118.26 60.62,117.78 arc(60.71,117.73) 60.81,117.7 72.65,115.21 arc(73.42,115.08) 74.21,115.01 77.14,114.89 arc(77.2,114.88) 77.26,114.89 78.21,114.94 arc(78.27,114.94) 78.33,114.94 82.4,114.56 arc(82.45,114.55) 82.51,114.55 82.86,114.48 arc(82.92,114.47) 82.97,114.44 83.95,113.83 arc(83.99,113.8) 84.04,113.76 84.92,112.92 arc(85.07,112.78) 85.22,112.66 85.56,112.4 arc(85.69,112.33) 85.82,112.3 86.77,112.2 arc(86.83,112.19) 86.88,112.19 91.47,112.19 99.92,112.5 133.46,112.5 arc(133.62,112.48) 133.78,112.43 135.64,111.57 arc(136.02,111.45) 136.41,111.42 137.62,111.47 arc(138.07,111.56) 138.48,111.8 139.63,112.77 arc(139.82,112.9) 140.03,112.99 144.44,114.44 147.59,115.73 arc(147.84,115.94) 147.94,116.26 147.94,116.55 arc(148.01,116.71) v1(148.17,116.78)
UPHY_TX0_N: length 118.5
  TOP w0.102: v3(70.52,130.5) 70.39,130.37 70.39,130.04 70.57,129.86 J1.J23
  IN1 w0.109: v1(158.31,184.11) 158.08,184.34 157.76,184.34 157.23,183.81 157.23,181.71 156.74,181.22 156.74,181.04 156.47,180.77 156.29,180.77 156.02,180.5 156.02,180.32 155.75,180.05 155.57,180.05 154.76,179.24 154.76,177.97 154.89,177.84 154.89,177.46 154.76,177.33 154.76,176.95 154.89,176.82 154.89,176.44 154.76,176.31 154.76,175.1 150.93,171.27 132.76,171.27 125.55,164.06 125.55,162.96 120.73,158.14 113.54,158.14 110.29,154.88 107.29,154.88 92.87,140.46 77.47,140.46 72.03,135.03 72.03,133.17 70.38,131.52 70.38,130.63 v3(70.52,130.5)
  BOTTOM w0.102: CA246.1 157.81,184.34 158.08,184.34 v1(158.31,184.11)
UPHY_TX0_P: length 118.6
  TOP w0.102: v3(69.98,130.5) 70.14,130.34 70.14,130.03 69.97,129.86 J1.J22
  IN1 w0.109: v3(69.98,130.5) 70.12,130.63 70.12,131.62 71.78,133.28 71.78,135.13 77.36,140.72 92.77,140.72 107.19,155.14 110.18,155.14 113.43,158.39 120.62,158.39 125.3,163.07 125.3,164.17 132.65,171.53 150.83,171.53 154.51,175.21 154.51,179.35 156.98,181.82 156.98,183.92 157.65,184.59 158.08,184.59 v1(158.31,184.82)
  BOTTOM w0.102: CA247.1 157.81,184.59 158.08,184.59 v1(158.31,184.82)
UPHY_TX10_N: length 102.8
  TOP w0.114: v3(59.98,132) 60.07,131.91 arc(60.11,131.84) 60.13,131.76 60.13,131.58 arc(60.07,131.42) 59.91,131.36 J1.K12 ; CM29.1 146.54,121.75 arc(146.67,121.81) 146.73,121.95 146.73,122.11 arc(146.68,122.23) 146.57,122.29 144.38,122.48 arc(144.22,122.5) 144.05,122.51 arc(143.4,122.6) 142.76,122.7 138.26,123.47 arc(138.2,123.48) 138.15,123.48 135.55,123.41 arc(135.26,123.37) 134.98,123.26 132.44,121.88 arc(132.37,121.85) 132.29,121.82 127.76,120.33 arc(127.17,120.07) 126.65,119.71 121.73,115.64 arc(121.29,115.34) 120.8,115.14 116,113.73 arc(115.37,113.59) 114.72,113.56 101.04,113.88 arc(100.48,113.91) 99.92,113.98 92.72,115.07 arc(92.67,115.07) 92.61,115.08 89.23,115.26 arc(89.17,115.26) 89.11,115.26 78.33,115.11 arc(78.24,115.12) 78.15,115.14 77.76,115.28 arc(77.7,115.3) 77.64,115.33 arc(76.9,115.69) 76.16,116.05 arc(75.99,116.2) 75.92,116.43 75.92,116.78 arc(75.85,116.94) v1(75.69,117.01)
  BOTTOM w0.114: v3(59.98,132) 60.07,131.91 arc(60.11,131.85) 60.12,131.78 60.12,131.62 arc(60.11,131.55) 60.07,131.49 59.43,130.88 arc(59.36,130.8) 59.31,130.72 58.85,129.78 arc(58.81,129.68) 58.8,129.56 58.8,128.81 arc(58.82,128.69) 58.87,128.58 59.09,128.2 arc(59.14,128.12) 59.21,128.05 60.4,127 60.4,127 arc(60.47,126.95) 60.54,126.9 61.3,126.48 arc(61.48,126.35) 61.61,126.18 62.81,124.09 arc(62.95,123.88) 63.13,123.71 67.41,120.27 arc(67.59,120.13) 67.79,120.02 68.8,119.5 arc(69.27,119.32) 69.76,119.25 74.81,119.08 arc(74.87,119.08) 74.92,119.06 75.26,118.88 arc(75.31,118.85) 75.35,118.81 75.54,118.61 arc(75.58,118.57) 75.6,118.52 75.91,117.79 arc(75.92,117.73) 75.93,117.67 75.93,117.37 arc(75.91,117.25) 75.84,117.15 v1(75.69,117.01)
UPHY_TX10_P: length 102.8
  TOP w0.114: v3(60.52,132) 60.46,131.94 arc(60.4,131.85) 60.38,131.76 60.38,131.58 arc(60.45,131.42) 60.6,131.36 J1.K13 ; CM1.1 147.17,121.75 arc(147.04,121.81) 146.98,121.95 146.98,122.11 arc(146.87,122.4) 146.59,122.54 144.4,122.73 arc(144.23,122.75) 144.06,122.77 arc(143.43,122.85) 142.8,122.95 138.3,123.72 arc(138.22,123.73) 138.14,123.74 135.55,123.67 arc(135.19,123.61) 134.86,123.48 132.32,122.1 arc(132.26,122.08) 132.21,122.06 127.68,120.57 arc(127.05,120.3) 126.49,119.91 121.57,115.83 arc(121.17,115.57) 120.73,115.39 115.93,113.97 arc(115.33,113.84) 114.73,113.81 101.05,114.13 arc(100.5,114.16) 99.96,114.23 92.76,115.32 arc(92.69,115.33) 92.62,115.33 89.24,115.51 arc(89.17,115.51) 89.11,115.51 78.34,115.37 arc(78.29,115.37) 78.23,115.38 77.85,115.52 arc(77.8,115.54) 77.75,115.56 arc(77.01,115.92) 76.27,116.27 arc(76.2,116.34) 76.17,116.43 76.17,116.78 arc(76.24,116.94) v1(76.4,117.01)
  BOTTOM w0.114: v3(60.52,132) 60.43,131.91 arc(60.39,131.85) 60.38,131.78 60.38,131.62 arc(60.34,131.44) 60.24,131.3 59.6,130.7 59.6,130.7 arc(59.57,130.65) 59.54,130.61 59.08,129.67 arc(59.06,129.62) 59.05,129.56 59.05,128.81 arc(59.06,128.76) 59.08,128.71 59.31,128.33 arc(59.34,128.28) 59.38,128.24 60.57,127.19 arc(60.62,127.15) 60.66,127.12 61.42,126.71 arc(61.66,126.53) 61.83,126.3 63.03,124.21 arc(63.14,124.05) 63.29,123.91 67.57,120.46 arc(67.73,120.35) 67.9,120.25 68.92,119.72 arc(69.33,119.57) 69.77,119.51 74.82,119.34 arc(74.94,119.32) 75.04,119.28 75.38,119.11 arc(75.46,119.05) 75.54,118.99 75.73,118.79 arc(75.79,118.7) 75.84,118.61 76.14,117.88 arc(76.17,117.78) 76.18,117.67 76.18,117.37 arc(76.21,117.24) 76.29,117.12 v1(76.4,117.01)
UPHY_TX11_N: length 103.3
  TOP w0.114: v3(60.52,128.99) 60.46,128.94 arc(60.4,128.85) 60.38,128.76 60.38,128.58 arc(60.45,128.42) 60.6,128.36 J1.H13 ; CM30.1 150.75,121.75 arc(150.88,121.81) 150.94,121.95 150.94,122.25 arc(150.9,122.38) 150.79,122.46 148.48,123.12 arc(148.42,123.13) 148.36,123.14 144.4,123.53 143.22,123.73 arc(143.11,123.77) 143,123.83 142.77,124.01 arc(142.7,124.08) 142.64,124.17 142.44,124.51 arc(142.4,124.56) 142.37,124.6 142.13,124.85 arc(142.09,124.89) 142.04,124.92 141.92,124.97 arc(141.87,125) 141.81,125.01 141.6,125.05 arc(141.54,125.05) 141.48,125.05 136.79,124.97 arc(136,124.86) 135.25,124.57 132.72,123.2 arc(132.66,123.17) 132.61,123.15 127.36,121.32 arc(126.79,121.07) 126.27,120.72 121.72,116.99 arc(120.67,116.3) 119.51,115.83 115.58,114.7 arc(115.11,114.6) 114.62,114.58 101.37,114.92 arc(100.86,114.95) 100.36,115.01 93.66,116.02 arc(93.6,116.03) 93.55,116.03 88.97,116.28 arc(88.95,116.28) 88.93,116.28 78.92,116.2 arc(78.63,116.32) 78.51,116.61 78.51,116.78 arc(78.44,116.94) v1(78.28,117.01)
  BOTTOM w0.114: v1(78.28,117.01) 78.43,117.15 arc(78.49,117.24) 78.51,117.35 78.51,117.52 arc(78.51,117.57) 78.49,117.63 78.44,117.76 arc(78.42,117.81) 78.38,117.86 77.91,118.42 77.71,118.44 77.48,118.71 77.5,118.91 76.93,119.58 arc(76.81,119.7) 76.66,119.79 75.4,120.42 arc(75.24,120.48) 75.07,120.51 71.67,120.73 arc(71.6,120.73) 71.52,120.75 70.87,120.9 arc(70.53,121.02) 70.23,121.21 69.24,122.01 69.05,121.99 68.77,122.22 68.75,122.41 68.47,122.63 68.28,122.61 68,122.84 67.98,123.03 67.7,123.25 arc(67.67,123.28) 67.62,123.31 66.69,123.99 66.5,123.96 66.21,124.17 66.18,124.37 65.89,124.58 65.7,124.54 65.41,124.75 65.38,124.95 64.15,125.84 arc(64.09,125.89) 64.04,125.93 62.97,126.93 arc(62.91,127) 62.85,127.07 62.55,127.56 62.36,127.6 62.17,127.9 62.21,128.09 62.02,128.39 61.83,128.43 61.64,128.73 61.68,128.92 61.49,129.22 arc(61.46,129.27) 61.41,129.3 61.18,129.47 arc(61.13,129.5) 61.08,129.51 60.53,129.54 arc(60.42,129.5) 60.38,129.39 60.38,129.24 arc(60.4,129.14) 60.45,129.06 v3(60.52,128.99)
UPHY_TX11_P: length 103.3
  TOP w0.114: J1.H12 59.91,128.36 arc(60.07,128.42) 60.13,128.58 60.13,128.76 arc(60.11,128.84) 60.07,128.91 v3(59.98,128.99) ; CM31.1 151.38,121.75 arc(151.25,121.81) 151.19,121.95 151.19,122.26 arc(151.1,122.54) 150.85,122.7 148.55,123.36 arc(148.47,123.38) 148.39,123.39 144.43,123.78 143.27,123.98 arc(143.21,124) 143.16,124.03 142.93,124.21 arc(142.89,124.25) 142.86,124.3 142.66,124.64 arc(142.61,124.71) 142.55,124.78 142.31,125.03 arc(142.24,125.09) 142.15,125.14 142.04,125.2 arc(141.95,125.24) 141.86,125.26 141.64,125.3 arc(141.56,125.31) 141.48,125.31 136.79,125.23 arc(135.94,125.11) 135.13,124.79 132.6,123.42 132.59,123.42 arc(132.56,123.4) 132.53,123.39 127.27,121.56 arc(126.66,121.29) 126.11,120.91 121.56,117.19 arc(120.55,116.53) 119.44,116.08 115.51,114.95 arc(115.07,114.86) 114.63,114.83 101.38,115.18 arc(100.89,115.2) 100.39,115.26 93.7,116.27 arc(93.63,116.28) 93.56,116.29 88.98,116.53 arc(88.95,116.53) 88.92,116.53 78.92,116.46 arc(78.81,116.5) 78.77,116.61 78.77,116.78 arc(78.83,116.94) v1(78.99,117.01)
  BOTTOM w0.114: v3(59.98,128.99) 60.05,129.06 arc(60.1,129.14) 60.12,129.24 60.12,129.39 arc(60.25,129.69) 60.55,129.79 61.09,129.76 arc(61.22,129.74) 61.33,129.68 61.56,129.51 arc(61.64,129.44) 61.71,129.36 63.07,127.21 arc(63.1,127.16) 63.14,127.12 64.21,126.12 arc(64.26,126.08) 64.3,126.05 67.77,123.52 arc(67.82,123.48) 67.86,123.45 70.39,121.41 arc(70.64,121.25) 70.93,121.15 71.58,121 arc(71.63,120.98) 71.69,120.98 75.09,120.76 arc(75.31,120.73) 75.52,120.65 76.78,120.02 arc(76.96,119.9) 77.12,119.75 78.58,118.02 arc(78.64,117.94) 78.68,117.85 78.73,117.72 arc(78.76,117.62) 78.77,117.52 78.77,117.35 arc(78.79,117.24) 78.85,117.15 v1(78.99,117.01)
USB2_0_N: length 99
  TOP w0.102: J1.F13 60.54,125.36 60.38,125.53 60.38,125.85 v3(60.52,126)
  IN1 w0.109: v3(60.52,126) 60.38,126.14 60.38,126.31 60.49,126.42 61.39,126.42 61.85,125.96 61.85,124.45 61.72,124.32 61.72,123.94 61.85,123.81 61.85,123.43 61.72,123.3 61.72,122.92 61.85,122.79 61.85,122.41 61.72,122.28 61.72,121.9 61.85,121.77 61.85,117.98 60.93,117.07 59.68,117.07 59.55,117.2 59.17,117.2 59.04,117.07 58.66,117.07 58.53,117.2 58.15,117.2 58.02,117.07 57.64,117.07 57.51,117.2 57.13,117.2 57,117.07 53.82,117.07 52.27,115.52 52.27,114.82 52.14,114.69 52.14,114.31 52.27,114.18 52.27,113.8 52.14,113.67 52.14,113.29 52.27,113.16 52.27,112.22 51.13,111.07 51.13,105.81 50.24,104.92 50.24,100.43 50.62,100.05 50.62,94.16 49.91,93.45 49.91,81.45 51.77,79.6 51.77,74.65 53.72,72.69 59.66,72.69 61.1,71.26 61.1,69.72 61.47,69.35 61.47,62.51 63.83,60.15 66.14,60.15 66.47,59.81 66.47,59.15 v1(66.24,58.92)
  BOTTOM w0.102: L7.1 63.61,53.57 63.88,53.85 63.88,55.8 66.47,58.39 66.47,58.69 v1(66.24,58.92)
USB2_0_P: length 99
  TOP w0.102: v3(59.98,126) 60.12,125.86 60.12,125.53 59.96,125.36 J1.F12
  IN1 w0.109: v1(66.95,58.92) 66.73,59.15 66.73,59.92 66.24,60.4 63.93,60.4 61.72,62.61 61.72,69.45 61.35,69.82 61.35,71.37 59.77,72.95 53.82,72.95 52.02,74.75 52.02,79.71 50.16,81.56 50.16,93.34 50.88,94.06 50.88,100.15 50.5,100.53 50.5,104.81 51.38,105.7 51.38,110.97 52.53,112.11 52.53,115.42 53.92,116.81 61.04,116.81 62.1,117.88 62.1,126.06 61.49,126.67 60.38,126.67 60.12,126.41 60.12,126.13 v3(59.98,126)
  BOTTOM w0.102: v1(66.95,58.92) 66.73,58.69 66.73,58.29 64.14,55.7 64.14,53.85 64.41,53.57 L7.4
USB2_1_N: length 139.1
  TOP w0.102: v3(57.98,121.5) 58.12,121.36 58.12,120.99 58,120.86 J1.C10
  IN1 w0.109: v3(57.98,121.5) 58.12,121.63 58.12,122.69 58.8,123.37 58.8,124.99 58.17,125.63 57.81,125.63 56.79,126.64 56.79,128.22 56.97,128.4 56.97,129.75 57.45,130.23 57.45,134.34 58.21,135.1 62.46,135.1 69.02,141.66 92.58,141.66 108.43,157.51 111.04,157.51 113.03,159.49 115.32,159.49 116.38,160.55 121.68,160.55 124.46,163.32 124.46,164.69 132.12,172.35 141.99,172.35 143.12,173.48 149.66,173.48 150.01,173.13 150.01,172.82 v1(150.24,172.59)
  BOTTOM w0.102: RZ144.1 157.96,177.85 FL1.1 158.27,177.55 158.58,177.55 158.83,177.3 158.83,176.58 158.47,176.23 158.47,175.13 156.44,173.1 150.14,173.1 150.04,173 150.04,172.8 v1(150.24,172.59)
USB2_1_P: length 139
  TOP w0.102: J1.C11 58.54,120.86 58.38,121.02 58.38,121.36 v3(58.52,121.5)
  IN1 w0.109: v1(149.53,172.59) 149.76,172.82 149.76,173.02 149.55,173.23 147.78,173.23 147.64,173.09 147.31,173.09 147.17,173.23 146.84,173.23 146.7,173.09 146.37,173.09 146.23,173.23 145.9,173.23 145.76,173.09 145.43,173.09 145.29,173.23 143.23,173.23 142.1,172.1 132.22,172.1 131.5,171.37 131.5,171.17 131.27,170.94 131.07,170.94 130.83,170.71 130.83,170.51 130.6,170.27 130.4,170.27 124.71,164.59 124.71,163.22 121.79,160.29 116.48,160.29 115.43,159.24 113.13,159.24 111.15,157.25 108.54,157.25 92.69,141.4 69.12,141.4 62.57,134.85 58.32,134.85 57.71,134.24 57.71,132.69 57.85,132.55 57.85,132.22 57.71,132.08 57.71,131.75 57.85,131.61 57.85,131.28 57.71,131.14 57.71,130.12 57.23,129.64 57.23,128.3 57.05,128.12 57.05,126.75 57.92,125.88 58.27,125.88 59.05,125.1 59.05,123.26 58.38,122.58 58.38,121.63 v3(58.52,121.5)
  BOTTOM w0.102: v1(149.53,172.59) 149.78,172.85 149.78,173.1 150.03,173.35 154.99,173.35 155.14,173.5 155.45,173.5 155.6,173.35 156.34,173.35 156.93,173.95 156.93,174.16 157.15,174.38 157.36,174.38 157.57,174.59 157.57,174.8 157.79,175.02 158,175.02 158.22,175.23 158.22,176.33 158.57,176.69 158.57,177.19 158.47,177.29 158.27,177.29 FL1.4 157.96,176.99 RZ146.1
USB2_1N_CON: length 18.9
  TOP w0.102: L2.2 110.39,55.06 110.67,54.79 111,54.79 111.17,54.62 111.38,54.62 111.5,54.75 D5.1 D5.10 112.92,54.75 113.04,54.62 113.32,54.62 113.49,54.79 113.49,57.87 113.34,58.02 113.34,58.33 113.49,58.48 113.49,58.78 113.34,58.93 113.34,59.24 113.49,59.39 113.49,59.69 113.34,59.84 113.34,60.15 113.49,60.3 113.49,62.76 113.31,63.29 113.11,63.38 113.02,63.67 113.11,63.86 113.01,64.15 112.82,64.24 112.72,64.53 112.81,64.72 112.69,65.08 112.39,65.38 112.04,65.51 111.53,65.51 110.97,65.68 110.78,65.88 110.38,66.53 110.29,66.59 110.13,66.59 110.03,66.48 CN1.2
USB2_1P_CON: length 18.9
  TOP w0.102: L2.3 110.39,54.26 110.67,54.53 110.9,54.53 111.06,54.37 111.38,54.37 111.5,54.25 D5.2 D5.9 112.9,54.25 113.02,54.37 113.42,54.37 113.74,54.69 113.74,62.8 112.91,65.22 112.53,65.6 112.08,65.76 111.57,65.76 111.11,65.91 110.98,66.04 110.56,66.71 110.37,66.84 110.16,66.84 110.03,66.96 CN1.3
USB2_2_N: length 73.2
  TOP w0.102: v1(82.3,113.2) 82.52,112.97 82.52,112.75 82.42,112.65 81.43,112.65 81.28,112.8 80.98,112.8 80.83,112.65 80.52,112.65 80.37,112.8 80.07,112.8 79.92,112.65 79.61,112.65 79.46,112.8 79.16,112.8 79.01,112.65 76.81,112.65 76.06,113.4 76.06,113.61 75.84,113.83 75.63,113.83 75.42,114.05 75.42,114.26 75.2,114.47 74.99,114.47 72.9,116.56 71.98,116.56 71.83,116.71 71.52,116.71 71.37,116.56 71.07,116.56 70.92,116.71 70.61,116.71 70.46,116.56 59.06,116.56 58.38,117.24 58.38,117.54 J1.A11 ; U20.32 81.22,71.27 81.3,71.34 81.3,71.44 81.25,71.48 81.25,72.03 81.3,72.07 81.3,73.53 81.93,74.16 81.93,75.41 v1(81.7,75.64)
  IN3 w0.109: v1(82.3,113.2) 82.52,112.97 82.52,110.29 81.33,109.09 81.33,100.08 79.65,98.4 79.65,83.82 80.72,82.75 80.72,77.28 81.93,76.07 81.93,75.87 v1(81.7,75.64)
USB2_2_P: length 73.2
  TOP w0.102: J1.A10 58.12,117.54 58.12,117.14 58.95,116.31 72.8,116.31 76.71,112.39 82.53,112.39 82.78,112.65 82.78,112.97 v1(83.01,113.2) ; v1(82.41,75.64) 82.18,75.41 82.18,74.06 81.55,73.42 81.55,71.96 81.51,71.92 81.51,71.59 81.55,71.55 81.55,71.38 81.62,71.31 U20.31
  IN3 w0.109: v1(82.41,75.64) 82.18,75.87 82.18,76.18 80.98,77.39 80.98,82.86 79.91,83.93 79.91,98.29 81.58,99.97 81.58,108.99 82.78,110.18 82.78,112.97 v1(83.01,113.2)
USB2_2N_CON: length 49.8
  TOP w0.102: CN2.2 82.65,44.68 82.55,44.78 82.55,45.21 82.94,45.59 90.22,45.59 96.36,39.45 104.85,39.45 107.14,41.73 111.25,41.73 113.87,44.35 113.87,52.65 113.41,53.11 113.01,53.11 112.87,53.25 D5.7 D5.4 111.54,53.25 111.42,53.12 111.07,53.12 110.83,52.88 110.67,52.88 110.39,53.16 L1.2
USB2_2P_CON: length 49.8
  TOP w0.102: CN2.3 82.19,44.68 82.3,44.78 82.3,45.31 82.83,45.85 90.32,45.85 96.47,39.7 104.75,39.7 107.03,41.99 111.15,41.99 113.61,44.45 113.61,47.54 113.46,47.69 113.46,47.99 113.61,48.14 113.61,48.45 113.46,48.6 113.46,48.9 113.61,49.05 113.61,52.55 113.31,52.86 112.98,52.86 112.87,52.75 D5.6 D5.5 111.54,52.75 111.42,52.87 111.17,52.87 110.93,52.63 110.67,52.63 110.39,52.36 L1.3
USB2_3_N: length 97.3
  TOP w0.102: 57.87,126.86 58.12,127.1 58.12,127.36 v3(57.98,127.5)
  TOP w0.127: J1.G10 57.87,126.86
  IN1 w0.109: v3(57.98,127.5) 58.12,127.63 58.12,127.99 58.37,128.24 59.23,128.24 59.64,127.84 60.88,127.84 61.08,128.04 62.2,128.04 64.29,125.96 64.29,117.33 66.78,114.83 71.68,114.83 73.91,112.6 73.91,110.16 74.42,109.65 81.43,109.65 83.44,111.66 88.26,111.66 90.15,113.55 123.73,113.55 128.22,118.03 129.28,118.03 129.54,117.78 129.54,117.56 v1(129.77,117.33)
  BOTTOM w0.102: RZ175.1 133.1,120.29 133.1,120.02 132.87,119.79 131.45,119.79 129.54,117.88 129.54,117.56 v1(129.77,117.33)
USB2_3_P: length 97.3
  TOP w0.102: 58.66,126.86 58.37,127.15 58.37,127.35 v3(58.52,127.5)
  TOP w0.127: J1.G11 58.66,126.86
  IN1 w0.109: v1(129.06,117.33) 129.29,117.56 129.29,117.67 129.18,117.78 128.32,117.78 127.2,116.66 127.2,116.48 126.93,116.21 126.75,116.21 126.48,115.94 126.48,115.75 126.21,115.48 126.03,115.48 123.84,113.3 90.26,113.3 88.37,111.4 83.54,111.4 81.53,109.4 74.32,109.4 73.66,110.05 73.66,112.49 73.15,113 72.96,113 72.7,113.27 72.7,113.46 72.43,113.73 72.24,113.73 71.97,114 71.97,114.18 71.57,114.58 66.67,114.58 66.29,114.96 66.11,114.96 65.84,115.23 65.84,115.42 65.57,115.68 65.39,115.68 65.12,115.95 65.12,116.14 64.03,117.22 64.03,122.08 63.9,122.21 63.9,122.59 64.03,122.72 64.03,123.1 63.9,123.23 63.9,123.61 64.03,123.74 64.03,125.85 62.1,127.79 61.19,127.79 60.99,127.58 59.53,127.58 59.13,127.99 58.48,127.99 58.37,127.88 58.37,127.64 v3(58.52,127.5)
  BOTTOM w0.102: RZ176.1 132.84,120.29 132.84,120.12 132.77,120.05 131.35,120.05 129.29,117.99 129.29,117.56 v1(129.06,117.33)
USB2_DWN_DM1: length 45.8
  TOP w0.102: U20.23 84.82,71.31 84.9,71.38 84.9,71.77 85.19,72.06 85.19,72.13 v1(84.98,72.34) ; L2.1 108.2,55.06 107.92,54.79 107.4,54.79 106.23,55.96 94.35,55.96 94.2,56.11 93.9,56.11 93.75,55.96 93.44,55.96 93.29,56.11 92.99,56.11 92.84,55.96 92.08,55.96 91.43,56.61 91.43,56.82 91.21,57.04 91,57.04 90.5,57.53 90.5,57.94 v1(90.73,58.17)
  IN3 w0.109: v1(90.73,58.17) 90.5,58.39 90.5,61.54 92.74,63.78 92.74,71.07 90.02,73.79 85.59,73.79 85.2,73.4 85.2,72.57 v1(84.98,72.34)
USB2_DWN_DM2: length 27.8
  TOP w0.102: L1.1 108.17,53.16 107.87,52.86 107.67,52.86 107.11,53.42 107.11,53.63 106.9,53.85 106.68,53.85 106.47,54.06 106.47,54.27 106.25,54.49 106.04,54.49 105.34,55.19 91.29,55.19 87.99,58.5 87.99,58.71 87.77,58.93 87.56,58.93 85.95,60.54 85.95,61.73 86.02,61.8 U20.76
USB2_DWN_DM3: length 84.8
  TOP w0.102: v1(139.14,68.9) 139.37,68.67 142.61,68.67 142.73,68.8 U13.6 ; U20.61 80.02,61.86 79.95,61.79 79.95,61.56 79.66,61.26 79.31,61.26 79.21,61.16 79.21,61.03 v1(79.43,60.81)
  IN1 w0.109: v1(79.43,60.81) 79.2,61.04 79.2,62.56 79.6,62.97 81,62.97 81.14,62.82 81.47,62.82 81.61,62.97 81.94,62.97 82.08,62.82 82.41,62.82 82.55,62.97 82.88,62.97 83.02,62.82 83.35,62.82 83.49,62.97 86.23,62.97 86.89,62.31 88.01,62.31 88.15,62.16 88.48,62.16 88.62,62.31 90.1,62.31 90.99,63.2 92.94,63.2 93.75,64.01 96.5,64.01 97,64.51 97,68.17 97.84,69.01 104.34,69.01 105.56,70.23 105.56,74.55 106.32,75.31 113.26,75.31 116.85,71.72 129.74,71.72 129.88,71.58 130.21,71.58 130.35,71.72 130.68,71.72 130.82,71.58 131.15,71.58 131.29,71.72 131.62,71.72 131.76,71.58 132.09,71.58 132.23,71.72 133.34,71.72 133.76,72.14 134.62,72.14 134.76,71.99 135.09,71.99 135.23,72.14 135.56,72.14 135.7,71.99 136.03,71.99 136.17,72.14 137.26,72.14 138.25,71.15 138.25,70.95 138.48,70.72 138.68,70.72 138.91,70.49 138.91,70.28 139.14,70.05 139.35,70.05 139.78,69.62 139.78,68.92 139.52,68.67 139.37,68.67 v1(139.14,68.9)
