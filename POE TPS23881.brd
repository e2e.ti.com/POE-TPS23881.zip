# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSI_5_D1_N: length 58.8
  TOP w0.102: v3(92.48,122.99) 92.63,122.85 92.63,122.49 92.5,122.36 J1.D45 ; v1(105.11,160.48) 104.88,160.71 104.88,160.96 105.06,161.14 109.4,161.14 111.88,163.61 111.88,164.25 112,164.37 J14.73
  BOTTOM w0.102: v1(105.11,160.48) 104.88,160.71 104.88,160.96 104.63,161.21 103.78,161.21 103.33,160.76 103.33,157.92 99.14,153.72 99.14,147.15 95.33,143.34 95.33,131.75 94.98,131.41 94.98,130.26 95.46,129.78 95.46,128.72 96.29,127.89 96.29,126.5 96.63,126.15 96.63,125 95.6,123.97 93.35,123.97 92.76,123.38 92.76,123.29 92.48,123.01 v3(92.48,122.99)
CSI_5_D1_P: length 58.8
  TOP w0.102: v1(104.39,160.48) 104.62,160.71 104.62,161.06 104.95,161.39 109.3,161.39 111.62,163.72 111.62,164.25 111.5,164.37 J14.71 ; J1.D46 93.03,122.36 92.88,122.51 92.88,122.86 v3(93.02,122.99)
  BOTTOM w0.102: v3(93.02,122.99) 93.02,123.27 93.46,123.71 93.73,123.71 93.88,123.56 94.18,123.56 94.33,123.71 94.64,123.71 94.79,123.56 95.09,123.56 95.24,123.71 95.7,123.71 96.02,124.03 96.23,124.03 96.44,124.24 96.44,124.46 96.89,124.9 96.89,126.26 96.54,126.6 96.54,127.99 95.71,128.83 95.71,129.89 95.24,130.36 95.24,131.3 95.58,131.65 95.58,143.23 99.39,147.04 99.39,153.62 101.24,155.47 101.45,155.47 101.67,155.69 101.67,155.9 101.89,156.12 102.1,156.12 102.31,156.33 102.31,156.54 102.53,156.76 102.74,156.76 102.96,156.97 102.96,157.19 103.58,157.81 103.58,158.68 103.73,158.83 103.73,159.14 103.58,159.29 103.58,159.59 103.73,159.74 103.73,160.05 103.58,160.2 103.58,160.66 103.89,160.96 104.52,160.96 104.62,160.86 104.62,160.71 v1(104.39,160.48)
CSI_6_CLK_N: length 76.1
  TOP w0.102: J14.46 100,172.15 99.88,172.27 99.88,172.96 v1(100.1,173.19) ; J1.J45 91.91,129.86 91.78,129.99 91.78,130.36 v3(91.92,130.5)
  IN3 w0.109: v1(100.1,173.19) 99.88,172.96 99.88,171.14 97.87,169.13 97.87,167.13 arc(97.94,166.95) 98.13,166.87 99.32,166.87 arc(99.69,166.71) 99.85,166.34 99.85,165.95 arc(99.7,165.59) 99.34,165.44 98.63,165.44 98.4,165.21 98.4,150.3 arc(98.25,149.95) 97.89,149.8 96.34,149.8 arc(96.17,149.72) 96.1,149.55 96.1,149.17 arc(96.18,148.96) 96.4,148.87 97.87,148.87 arc(98.23,148.72) 98.38,148.36 98.38,147.99 arc(98.22,147.6) 97.84,147.44 95.97,147.44 arc(95.76,147.36) 95.67,147.14 95.67,146.79 arc(95.75,146.6) 95.94,146.52 96.63,146.52 arc(97.02,146.36) 97.18,145.97 97.18,145.67 arc(97.01,145.26) 96.6,145.09 93.71,145.09 arc(93.38,144.96) 93.24,144.63 93.24,144.48 arc(93.33,144.26) 93.55,144.17 94.26,144.17 arc(94.64,144.01) 94.79,143.64 94.79,143.28 arc(94.63,142.9) 94.25,142.74 91.36,142.74 arc(91.18,142.67) 91.11,142.49 91.11,142.14 arc(91.2,141.91) 91.43,141.82 92.56,141.82 arc(92.93,141.66) 93.09,141.28 93.09,140.92 arc(92.93,140.54) 92.56,140.39 91.37,140.39 arc(91.18,140.31) 91.11,140.13 91.11,139.75 arc(91.19,139.55) 91.39,139.47 92.59,139.47 arc(92.94,139.32) 93.09,138.96 93.09,138.57 arc(92.93,138.19) 92.56,138.04 91.38,138.04 arc(91.19,137.96) 91.11,137.77 91.11,137.37 arc(91.18,137.19) 91.36,137.11 92.56,137.11 arc(92.93,136.96) 93.09,136.58 93.09,136.22 arc(92.93,135.84) 92.56,135.68 91.36,135.68 arc(91.18,135.61) 91.11,135.43 91.11,135.08 arc(91.2,134.85) 91.42,134.76 91.9,134.76 arc(92.31,134.59) 92.48,134.18 92.48,131.66 91.81,130.99 91.81,130.6 v3(91.92,130.5)
CSI_6_CLK_P: length 76.2
  TOP w0.102: v3(91.38,130.5) 91.53,130.35 91.53,129.99 91.4,129.86 J1.J44 ; J14.44 99.5,172.11 99.62,172.24 99.62,172.96 v1(99.39,173.19)
  IN3 w0.109: v3(91.38,130.5) 91.54,130.65 91.54,131.1 92.23,131.79 92.23,134.18 arc(92.13,134.41) 91.9,134.51 91.42,134.51 arc(91.02,134.67) 90.86,135.08 90.86,135.43 arc(91,135.79) 91.36,135.94 92.56,135.94 arc(92.76,136.02) 92.84,136.22 92.84,136.58 arc(92.76,136.78) 92.56,136.86 91.36,136.86 arc(91,137.01) 90.86,137.37 90.86,137.77 arc(91.01,138.14) 91.38,138.29 92.56,138.29 arc(92.76,138.37) 92.84,138.57 92.84,138.96 arc(92.76,139.14) 92.59,139.21 91.39,139.21 arc(91.01,139.37) 90.86,139.75 90.86,140.13 arc(91.01,140.49) 91.37,140.64 92.56,140.64 arc(92.76,140.72) 92.84,140.92 92.84,141.28 arc(92.76,141.48) 92.56,141.56 91.43,141.56 arc(91.02,141.73) 90.86,142.14 90.86,142.49 arc(91,142.85) 91.36,142.99 94.25,142.99 arc(94.45,143.08) 94.54,143.28 94.54,143.64 arc(94.46,143.83) 94.26,143.92 93.55,143.92 arc(93.15,144.08) 92.99,144.48 92.99,144.63 arc(93.2,145.14) 93.71,145.35 96.6,145.35 arc(96.83,145.44) 96.93,145.67 96.93,145.97 arc(96.84,146.18) 96.63,146.27 95.94,146.27 arc(95.57,146.42) 95.42,146.79 95.42,147.14 arc(95.58,147.54) 95.97,147.7 97.84,147.7 arc(98.04,147.78) 98.13,147.99 98.13,148.36 arc(98.05,148.54) 97.87,148.62 96.4,148.62 arc(96,148.78) 95.84,149.17 95.84,149.55 arc(95.99,149.9) 96.34,150.05 97.89,150.05 arc(98.07,150.12) 98.15,150.3 98.15,165.31 98.52,165.69 99.34,165.69 arc(99.52,165.77) 99.59,165.95 99.59,166.34 arc(99.51,166.53) 99.32,166.61 98.13,166.61 arc(97.76,166.77) 97.61,167.13 97.61,169.24 99.62,171.25 99.62,172.96 v1(99.39,173.19)
CSI_6_D0_N: length 76.2
  TOP w0.102: v3(90.68,132) 90.8,131.88 90.8,131.51 90.66,131.36 J1.K43 ; J14.40 98.5,172.15 98.38,172.27 98.38,173.25 98.73,173.61 98.73,174.57 v1(98.96,174.8)
  IN3 w0.109: v1(98.96,174.8) 98.73,175.02 98.73,175.28 98.5,175.51 97.62,175.51 97.28,175.18 97.28,173.83 97.94,173.17 97.94,171.04 96.57,169.67 96.57,166.33 arc(96.49,166.14) 96.29,166.05 93.74,166.05 arc(93.35,165.89) 93.19,165.51 93.19,165.18 arc(93.36,164.79) 93.75,164.62 96.26,164.62 arc(96.48,164.53) 96.57,164.31 96.57,161.29 arc(96.48,161.07) 96.27,160.99 95.66,160.99 arc(95.24,160.81) 95.07,160.4 95.07,159.41 arc(95.24,158.99) 95.66,158.82 97.11,158.82 arc(97.28,158.75) 97.36,158.57 97.36,158.18 arc(97.28,157.98) 97.08,157.9 95.62,157.9 arc(95.23,157.74) 95.07,157.35 95.07,157.02 arc(95.23,156.63) 95.62,156.47 97.1,156.47 arc(97.28,156.39) 97.36,156.21 97.36,155.8 arc(97.28,155.62) 97.1,155.55 95.58,155.55 arc(95.22,155.4) 95.07,155.04 95.07,154.69 arc(95.24,154.29) 95.64,154.12 97.09,154.12 arc(97.28,154.04) 97.36,153.85 97.36,153.47 arc(97.28,153.28) 97.09,153.2 95.62,153.2 arc(95.23,153.04) 95.07,152.65 95.07,152.3 arc(95.23,151.92) 95.6,151.77 97.1,151.77 arc(97.28,151.69) 97.36,151.51 97.36,151.12 arc(97.28,150.93) 97.08,150.85 95.63,150.85 arc(95.23,150.68) 95.07,150.29 95.07,148.13 90.07,143.13 90.07,133.2 90.79,132.47 90.79,132.1 v3(90.68,132)
CSI_6_D0_P: length 76.2
  TOP w0.102: J1.K44 91.2,131.36 91.06,131.5 91.06,131.83 v3(91.22,132) ; v1(98.25,174.8) 98.48,174.57 98.48,173.71 98.12,173.35 98.12,172.26 98,172.14 J14.38
  IN3 w0.109: v3(91.22,132) 91.05,132.17 91.05,132.58 90.32,133.31 90.32,143.02 95.33,148.03 95.33,150.29 arc(95.41,150.5) 95.63,150.59 97.08,150.59 arc(97.46,150.75) 97.61,151.12 97.61,151.51 arc(97.46,151.87) 97.1,152.02 95.6,152.02 arc(95.41,152.1) 95.33,152.3 95.33,152.65 arc(95.41,152.86) 95.62,152.94 97.09,152.94 arc(97.46,153.1) 97.61,153.47 97.61,153.85 arc(97.46,154.22) 97.09,154.37 95.64,154.37 arc(95.42,154.46) 95.33,154.69 95.33,155.04 arc(95.4,155.22) 95.58,155.3 97.1,155.3 arc(97.46,155.44) 97.61,155.8 97.61,156.21 arc(97.46,156.57) 97.1,156.73 95.62,156.73 arc(95.41,156.81) 95.33,157.02 95.33,157.35 arc(95.41,157.56) 95.62,157.65 97.08,157.65 arc(97.46,157.8) 97.61,158.18 97.61,158.57 arc(97.46,158.93) 97.11,159.08 95.66,159.08 arc(95.42,159.17) 95.33,159.41 95.33,160.4 arc(95.42,160.63) 95.66,160.73 96.27,160.73 arc(96.66,160.89) 96.82,161.29 96.82,164.31 arc(96.66,164.71) 96.26,164.88 93.75,164.88 arc(93.54,164.97) 93.45,165.18 93.45,165.51 arc(93.53,165.71) 93.74,165.8 96.29,165.8 arc(96.67,165.96) 96.82,166.33 96.82,166.75 96.97,166.89 96.97,167.22 96.82,167.36 96.82,167.69 96.97,167.83 96.97,168.16 96.82,168.3 96.82,168.63 96.97,168.77 96.97,169.1 96.82,169.24 96.82,169.57 97.23,169.97 97.43,169.97 97.67,170.21 97.67,170.41 98.2,170.94 98.2,171.4 98.34,171.54 98.34,171.87 98.2,172.01 98.2,172.34 98.34,172.48 98.34,172.81 98.2,172.95 98.2,173.28 97.54,173.94 97.54,175.07 97.72,175.26 98.4,175.26 98.48,175.18 98.48,175.02 v1(98.25,174.8)
CSI_6_D1_N: length 76.4
  TOP w0.102: J1.H45 92.48,128.36 92.63,128.51 92.63,128.85 v3(92.48,128.99) ; v1(101.96,174.8) 101.73,174.57 101.73,173.61 101.38,173.25 101.38,172.27 101.5,172.15 J14.52
  IN3 w0.109: v1(101.96,174.8) 101.73,175.02 101.73,175.21 101.47,175.46 100.58,175.46 100.2,175.08 100.2,173.94 101.19,172.95 101.19,171.19 arc(101.34,170.83) 101.7,170.68 104.73,170.68 arc(104.96,170.59) 105.05,170.36 105.05,170.1 arc(104.95,169.86) 104.71,169.76 101.42,169.76 arc(101.03,169.59) 100.86,169.2 100.86,168.54 arc(101.02,168.16) 101.4,168.01 102.32,168.01 arc(102.51,167.93) 102.59,167.74 102.59,167.34 arc(102.52,167.16) 102.34,167.09 100.94,167.09 arc(100.55,166.92) 100.38,166.52 100.38,166.04 arc(100.53,165.67) 100.91,165.51 103.78,165.51 arc(103.98,165.43) 104.06,165.23 104.06,164.87 arc(103.98,164.67) 103.78,164.59 100.03,164.59 99.72,164.28 99.72,162.92 arc(99.68,162.81) 99.57,162.76 99.34,162.76 arc(99.05,162.64) 98.92,162.35 98.92,161.77 arc(99.05,161.46) 99.35,161.33 99.75,161.33 arc(99.93,161.26) 100,161.08 100,160.64 arc(99.93,160.48) 99.77,160.41 99.24,160.41 98.92,160.09 98.92,146.42 93.72,141.22 93.72,133.42 93,132.7 93,130.1 92.62,129.72 92.62,129.13 v3(92.48,128.99)
CSI_6_D1_P: length 76.4
  TOP w0.102: J14.50 101,172.14 101.12,172.26 101.12,173.35 101.48,173.71 101.48,174.57 v1(101.25,174.8) ; v3(93.02,128.99) 92.88,128.86 92.88,128.49 93.01,128.36 J1.H46
  IN3 w0.109: v3(93.02,128.99) 92.89,129.12 92.89,129.63 93.25,129.99 93.25,132.59 93.97,133.31 93.97,141.12 99.17,146.31 99.17,159.98 99.35,160.16 99.77,160.16 arc(100.11,160.3) 100.25,160.64 100.25,161.08 arc(100.11,161.44) 99.75,161.59 99.35,161.59 arc(99.23,161.64) 99.18,161.77 99.18,162.35 arc(99.22,162.46) 99.34,162.51 99.57,162.51 arc(99.85,162.63) 99.97,162.92 99.97,164.18 100.13,164.34 101.04,164.34 101.18,164.2 101.51,164.2 101.65,164.34 101.98,164.34 102.12,164.2 102.45,164.2 102.59,164.34 103.78,164.34 arc(104.16,164.49) 104.32,164.87 104.32,165.23 arc(104.16,165.61) 103.78,165.77 102.85,165.77 102.7,165.91 102.38,165.91 102.23,165.77 101.91,165.77 101.76,165.91 101.44,165.91 101.29,165.77 100.91,165.77 arc(100.71,165.85) 100.63,166.04 100.63,166.52 arc(100.73,166.74) 100.94,166.83 102.34,166.83 arc(102.7,166.98) 102.84,167.34 102.84,167.74 arc(102.69,168.11) 102.32,168.26 101.4,168.26 arc(101.2,168.34) 101.12,168.54 101.12,169.2 arc(101.21,169.41) 101.42,169.5 104.71,169.5 arc(105.13,169.68) 105.31,170.1 105.31,170.36 arc(105.14,170.76) 104.73,170.93 103.86,170.93 103.72,171.08 103.39,171.08 103.25,170.93 102.92,170.93 102.78,171.08 102.45,171.08 102.31,170.93 101.7,170.93 arc(101.52,171.01) 101.45,171.19 101.45,173.05 101.22,173.29 101.22,173.49 100.98,173.72 100.78,173.72 100.46,174.04 100.46,174.98 100.69,175.21 101.37,175.21 101.48,175.1 101.48,175.02 v1(101.25,174.8)
CSI_7_CLK_N: length 76.3
  TOP w0.102: J1.B46 93.01,119.36 92.88,119.49 92.88,119.86 v3(93.02,120) ; v1(110.6,173.3) 110.53,173.3 110.38,173.14 110.38,172.27 110.5,172.15 J14.68
  BOTTOM w0.102: v1(110.6,173.3) 110.38,173.52 110.38,173.79 110.13,174.04 107.26,174.04 105,171.78 105,170.33 105.97,169.36 105.97,167.08 107.85,165.2 107.85,158.73 101.6,152.48 101.6,146.25 100.2,144.86 100.2,136.05 98.04,133.89 98.04,130.18 98.58,129.64 98.58,128.5 99.19,127.89 99.19,127.28 100.2,126.26 100.2,125.27 100.39,125.08 100.39,122.65 99.93,122.19 99.93,121.37 99.42,120.85 99.42,119.81 98.9,119.29 92.98,119.29 92.88,119.39 92.88,119.86 v3(93.02,120)
CSI_7_CLK_P: length 76.4
  TOP w0.102: v3(92.48,120) 92.63,119.85 92.63,119.49 92.5,119.36 J1.B45 ; v1(109.89,173.3) 109.97,173.3 110.12,173.14 110.12,172.26 110,172.14 J14.66
  BOTTOM w0.102: v3(92.48,120) 92.62,119.86 92.62,119.29 92.87,119.04 99.01,119.04 99.67,119.7 99.67,120.74 100.19,121.26 100.19,122.08 100.65,122.54 100.65,125.18 100.46,125.37 100.46,126.37 99.44,127.38 99.44,127.99 98.83,128.6 98.83,129.75 98.3,130.28 98.3,133.78 100.46,135.94 100.46,144.75 101.85,146.15 101.85,152.37 108.1,158.62 108.1,165.3 106.22,167.18 106.22,169.47 105.26,170.43 105.26,171.68 107.37,173.79 110.02,173.79 110.12,173.69 110.12,173.52 v1(109.89,173.3)
CSI_7_D0_N: length 75.8
  TOP w0.102: J14.62 v1(106.55,171.12) ; J1.A45 91.91,117.86 91.78,117.99 91.78,118.36 v3(91.92,118.5)
  BOTTOM w0.102: v3(91.92,118.5) 91.78,118.36 91.78,118.21 91.91,118.07 95.35,118.07 95.5,118.22 95.81,118.22 95.96,118.07 98,118.07 98.15,118.22 98.45,118.22 98.6,118.07 98.91,118.07 99.05,118.22 99.36,118.22 99.51,118.07 100.07,118.07 100.53,118.54 100.53,118.95 100.38,119.1 100.38,119.41 100.53,119.56 100.53,119.86 100.38,120.01 100.38,120.31 100.53,120.46 100.53,120.79 100.86,121.12 100.86,121.86 101.75,122.75 101.75,123.38 101.59,123.54 101.59,124.92 101.44,125.07 101.44,125.37 101.59,125.52 101.59,126.12 100.46,127.25 100.46,127.89 99.36,128.98 99.36,130.12 98.81,130.68 98.81,133.45 100.99,135.64 100.99,144.48 103.28,146.77 103.28,153.08 108.76,158.56 108.76,161.89 108.61,162.04 108.61,162.34 108.76,162.49 108.76,162.8 108.61,162.95 108.61,163.25 108.76,163.4 108.76,163.71 108.61,163.86 108.61,164.16 108.76,164.31 108.76,165.6 108.54,165.82 108.33,165.82 108.12,166.04 108.12,166.25 107.9,166.47 107.69,166.47 107.47,166.68 107.47,166.89 106.96,167.41 106.96,168 106.81,168.15 106.81,168.46 106.96,168.61 106.96,168.91 106.81,169.06 106.81,169.37 106.96,169.52 106.96,170 107.19,170.23 107.19,171.65 107.01,171.83 106.5,171.83 106.32,171.65 106.32,171.35 v1(106.55,171.12)
CSI_7_D0_P: length 75.8
  TOP w0.102: J1.A44 91.4,117.86 91.53,117.99 91.53,118.35 v3(91.38,118.5) ; v1(105.84,171.12) J14.60
  BOTTOM w0.102: v3(91.38,118.5) 91.52,118.36 91.52,118.1 91.81,117.82 100.17,117.82 100.79,118.44 100.79,120.69 101.12,121.02 101.12,121.75 102.01,122.64 102.01,123.49 101.85,123.65 101.85,126.22 100.71,127.36 100.71,127.99 99.62,129.09 99.62,130.23 99.06,130.79 99.06,133.35 101.24,135.53 101.24,144.37 103.53,146.66 103.53,152.97 109.02,158.46 109.02,165.71 107.21,167.51 107.21,169.9 107.44,170.13 107.44,171.76 107.12,172.09 106.4,172.09 106.07,171.76 106.07,171.35 v1(105.84,171.12)
CSI_7_D1_N: length 76.6
  TOP w0.102: v1(112.1,173.93) 111.88,173.7 111.88,172.27 112,172.15 J14.74 ; v3(94.62,121.5) 94.48,121.36 94.48,120.98 94.6,120.86 J1.C48
  BOTTOM w0.102: v1(112.1,173.93) 111.88,174.16 111.88,174.64 111.51,175.01 107.11,175.01 104.14,172.04 104.14,170.02 105.21,168.96 105.21,166.72 107.09,164.84 107.09,159.04 100.76,152.72 100.76,146.56 98.78,144.58 98.78,135.74 97.28,134.24 97.28,129.79 97.81,129.26 97.81,127.13 98.16,126.79 98.16,125.49 98.55,125.09 99.3,125.09 99.63,124.76 99.63,122.96 98.37,121.71 98.37,121.2 97.97,120.79 94.58,120.79 94.48,120.9 94.48,121.36 v3(94.62,121.5)
CSI_7_D1_P: length 76.6
  TOP w0.102: v1(111.39,173.93) 111.62,173.7 111.62,172.24 111.5,172.11 J14.72 ; v3(94.08,121.5) 94.23,121.35 94.23,120.99 94.1,120.86 J1.C47
  BOTTOM w0.102: v3(94.08,121.5) 94.22,121.36 94.22,120.79 94.47,120.54 98.08,120.54 98.63,121.09 98.63,121.6 99.88,122.86 99.88,124.87 99.4,125.35 98.66,125.35 98.41,125.6 98.41,126.89 98.07,127.23 98.07,129.37 97.54,129.9 97.54,134.13 99.03,135.63 99.03,144.48 101.02,146.46 101.02,152.61 107.34,158.94 107.34,164.95 105.46,166.83 105.46,169.06 104.39,170.13 104.39,171.93 107.21,174.75 111.4,174.75 111.62,174.54 111.62,174.16 v1(111.39,173.93)
CTS2#: length 2
  TOP w0.107: v1(77.34,158.62) 77.37,158.65 U25.20
  BOTTOM w0.107: v1(77.34,158.62) 78.33,158.62 R174.1
CVB_STBY: length 4.2
  TOP w0.305: Z8.2 117.58,132.58 118.09,133.1 U33.4 119.42,133.59 RZU8.2 RZU9.1
CVM_PRSNT: length 35.2
  TOP w0.107: J1.L63 108.3,135.73 v1(108.58,136.02) ; Q4.G 111.49,151.02 v1(111.76,150.75)
  IN1 w0.124: v1(108.58,136.02) 110.9,136.02 112.67,137.79 112.67,148.95 111.76,149.86 v1(111.76,150.75)
  BOTTOM w0.107: v1(111.76,150.75) 111.76,151.71 RZU38.1 111.86,151.82 R51.2 111.99,153.03 114.2,153.03 114.86,153.7 PSON1.4 PSON1.3
DCD2#: length 2.2
  TOP w0.107: U25.19 77.51,159.04 TP38.1
DIO_INT#: length 18.8
  TOP w0.107: U13.18 v1(140.83,74.68) ; RZU31.1 v1(126.14,70.23)
  IN3 w0.124: v1(126.14,70.23) 127.41,71.5 132.99,71.5 136.7,75.21 140.29,75.21 v1(140.83,74.68)
DIO_SCL: length 9.8
  TOP w0.107: U14.12 125.25,72.9 125.37,72.77 126.39,72.77 126.64,72.52 126.64,70.87 129.22,68.3 U13.44
DIO_SDA: length 9.1
  TOP w0.107: U14.13 126.67,73.46 127.03,73.1 127.03,71.03 129.26,68.8 U13.43
DM: length 3.4
  TOP w0.102: U25.37 81.28,152 81.36,151.92 81.36,151.46 82.11,150.71 82.11,150.03 RZ9.1
DP: length 3.4
  TOP w0.102: RZ10.1 82.36,150.03 82.36,150.81 81.61,151.56 81.61,151.92 81.68,151.98 U25.38
DP2_AUX_CH_N_I2C6_DAT: length 43.5
  TOP w0.107: v1(99.97,88.65) 99.86,88.53 U66.47 ; v1(99.95,127.51) 100.2,127.26 J1.G54
  IN3 w0.124: v1(99.95,127.51) 100.2,127.26 100.2,121.49 100.9,120.79 100.9,115.2 100.2,114.5 100.2,105.46 102.77,102.89 102.77,98.88 102.97,98.68 102.97,94.29 102.28,93.6 102.28,90.95 v1(99.97,88.65)
DP2_AUX_CH_P_I2C6_CLK: length 43.6
  TOP w0.107: U66.48 99.5,88.93 99.85,89.28 v1(99.97,89.28) ; J1.G53 98.83,126.39 v1(98.83,126.11)
  IN3 w0.124: v1(98.83,126.11) 98.77,126.05 98.77,123.89 99.77,122.89 99.77,121.31 100.47,120.61 100.47,115.38 99.77,114.68 99.77,105.28 101,104.05 101,103.34 arc(101.18,102.92) 101.6,102.74 102.04,102.74 arc(102.25,102.65) 102.34,102.44 102.34,102.31 arc(102.25,102.1) 102.03,102.01 101.78,102.01 arc(101.54,101.91) 101.45,101.68 101.45,101.57 arc(101.54,101.36) 101.75,101.27 102.01,101.27 arc(102.24,101.17) 102.34,100.94 102.34,98.7 102.54,98.5 102.54,94.47 101.85,93.78 101.85,91.25 99.97,89.37 v1(99.97,89.28)
DP2_HPD_CH0_HPD: length 61.1
  TOP w0.107: J1.K50 v1(96.8,132.02)
  IN3 w0.124: v1(94.36,98.81) 93.19,99.97 93.19,106.86 93.01,107.04 93.01,116.66 93.97,117.61 93.97,118.76 95.16,119.95 95.16,120.81 95.61,121.26 95.61,122.02 96.14,122.56 96.4,122.56 96.65,122.81 96.65,124.44 97.69,125.48 97.69,131.13 v1(96.8,132.02)
  BOTTOM w0.107: v1(94.36,98.81) 94.92,99.36 102.11,99.36 105.54,95.94 R541.2 105.54,89.46 106.07,88.93 Q55.D 105.44,87.76 R540.1 RZU45.1
DPE_CLKN0: length 8
  TOP w0.114: U70.75 48.2,66.26 48.12,66.33 44.92,66.33 44.77,66.48 41.31,66.48 RZ87.1
DPE_CLKN1: length 4.5
  TOP w0.114: RZ93.1 44.87,65.21 45.66,65.21 45.97,65.53 48.08,65.53 48.16,65.46 U70.77
DPE_CLKN2: length 8.3
  TOP w0.114: U70.79 48.2,64.66 48.12,64.73 46.44,64.73 45.66,63.94 41.31,63.94 RZ94.1
DPE_CLKP0: length 8
  TOP w0.114: RZ84.1 41.31,66.74 44.87,66.74 45.03,66.58 48.12,66.58 48.19,66.66 U70.74
DPE_CLKP1: length 4.5
  TOP w0.114: U70.76 48.2,65.86 48.13,65.78 45.87,65.78 45.55,65.47 44.87,65.47 RZ88.1
DPE_CLKP2: length 8.3
  TOP w0.114: U70.78 48.22,65.06 48.14,64.98 46.34,64.98 45.55,64.2 41.31,64.2 RZ92.1
DPE_CLKREQN0: length 4.7
  TOP w0.107: R625.2 51.1,74.62 51.1,71.61 51.76,70.95 U70.60
DPE_CLKREQN1: length 7.1
  TOP w0.107: U70.61 51.36,70.97 50.71,71.61 50.71,74.19 50.58,74.33 50.58,76.89 R626.2
DPE_CLKREQN2: length 4.8
  TOP w0.107: R627.2 49.99,74.37 50.33,74.03 50.33,71.58 50.96,70.95 U70.62
DPE_CLKREQN3: length 7.1
  TOP w0.107: U70.64 50.16,70.77 49.8,71.13 49.69,71.13 49.35,71.47 R628.2
DPE_RSTN_R: length 2.7
  BOTTOM w0.107: U67.A3 52.8,104.98 51.23,104.98 RZ182.2
DPE_RXN0: length 7.7
  TOP w0.114: RZ107.1 57.35,53.24 57.35,56.49 57.29,56.56 57.29,59.78 57.36,59.85 U70.21
DPE_RXN1: length 4.7
  TOP w0.114: U70.12 53.76,59.85 53.69,59.78 53.69,59.27 53.65,59.24 53.65,56.31 RZ102.1
DPE_RXN6: length 8
  TOP w0.114: RZ97.1 41.31,61.53 48.1,61.53 48.17,61.46 U70.87
DPE_RXP0: length 7.7
  TOP w0.114: RZ106.1 57.1,53.26 57.1,56.38 57.03,56.45 57.03,59.78 56.96,59.86 U70.20
DPE_RXP1: length 4.7
  TOP w0.114: U70.11 53.36,59.85 53.43,59.78 53.43,59.38 53.4,59.34 53.4,56.29 RZ101.1
DPE_RXP6: length 8
  TOP w0.114: U70.86 48.17,61.86 48.09,61.78 41.32,61.78 RZ96.1
DPE_TXN0: length 4.7
  TOP w0.114: CM61.1 56.09,56.27 56.09,59.78 56.16,59.85 U70.18
DPE_TXN1: length 7.7
  TOP w0.114: U70.15 54.96,59.85 54.89,59.78 54.89,53.15 CM63.1
DPE_TXN6: length 4.4
  TOP w0.114: U70.84 48.11,62.66 48.03,62.73 44.78,62.73 CM59.1
DPE_TXP0: length 4.6
  TOP w0.114: CM60.1 55.83,56.17 55.83,59.78 55.76,59.86 U70.17
DPE_TXP1: length 7.7
  TOP w0.114: U70.14 54.56,59.86 54.63,59.78 54.63,53.2 CM62.1
DPE_TXP6: length 4.4
  TOP w0.114: U70.83 48.11,63.06 48.03,62.98 44.8,62.98 CM58.1
DSR2#: length 2.1
  TOP w0.107: U25.32 v1(79.3,153.85)
  BOTTOM w0.107: v1(79.3,153.85) 78.84,153.85 78.71,153.97 R172.1
DSR4#: length 1.9
  TOP w0.107: U25.55 v1(85.93,156.25)
  BOTTOM w0.107: v1(85.93,156.25) 85.18,156.25 R175.1
DTR2: length 5.2
  TOP w0.107: U25.29 77.57,155.04 76.32,153.8 75.31,153.8 74.42,152.91 TP37.1
E_TX0N_A: length 3.1
  TOP w0.089: R522.1 94.16,79.78 94.16,80.04 94.75,80.63 94.75,81.65 94.69,81.71 U66.23
E_TX0N_R_A: length 1.8
  TOP w0.089: R522.2 94.16,77.95 94.16,77.03 CB23.2
E_TX0P_A: length 3.1
  TOP w0.089: R521.1 94.44,79.78 94.44,79.92 95.03,80.51 95.03,81.65 95.09,81.71 U66.24
E_TX0P_R_A: length 1.8
  TOP w0.089: R521.2 94.44,77.95 94.44,77.03 CB24.2
E_TX1N_A: length 3.1
  TOP w0.089: U66.26 95.89,81.68 95.95,81.62 95.95,80.51 96.44,80.02 96.44,79.78 R520.1
E_TX1N_R_A: length 1.8
  TOP w0.089: CB25.2 96.44,77.03 96.44,77.95 R520.2
E_TX1P_A: length 3.1
  TOP w0.089: R518.1 96.72,79.78 96.72,80.14 96.23,80.63 96.23,81.6 96.29,81.66 U66.27
E_TX1P_R_A: length 1.8
  TOP w0.089: R518.2 96.72,77.95 96.72,77.03 CB26.2
E_TX2N_A: length 3.8
  TOP w0.089: R517.1 98.7,79.76 98.7,79.87 98.51,80.06 98,80.06 97.16,80.91 97.16,81.64 97.09,81.7 U66.29
E_TX2N_R_A: length 1.8
  TOP w0.089: R517.2 98.73,77.95 98.73,77.03 CB27.2
E_TX2P_A: length 3.8
  TOP w0.089: R516.1 98.98,79.78 98.98,79.98 98.63,80.34 98.12,80.34 97.43,81.03 97.43,81.66 97.49,81.72 U66.30
E_TX2P_R_A: length 1.8
  TOP w0.089: CB28.2 99.01,77.03 99.01,78.02 R516.2
E_TXCN_A: length 4.1
  TOP w0.089: R524.1 91.9,79.81 91.9,80.14 92.15,80.39 92.94,80.39 93.57,81.03 93.57,81.64 93.49,81.72 U66.20
E_TXCN_R_A: length 1.8
  TOP w0.089: R524.2 91.87,77.95 91.87,77.03 CB21.2
E_TXCP_A: length 4
  TOP w0.089: U66.21 93.89,81.67 93.85,81.64 93.85,80.91 93.05,80.11 92.27,80.11 92.18,80.02 92.18,79.76 R523.1
E_TXCP_R_A: length 1.8
  TOP w0.089: R523.2 92.15,77.95 92.15,77.03 CB22.2
EEPROM_A0: length 7
  TOP w0.107: R98.2 39.42,109.7 39.19,109.93 39.19,111.84 39.47,112.12 RB26.1 TP23.1 40.05,113.71 U15.1
EEPROM_A1: length 6.9
  TOP w0.107: U15.2 41.32,113.58 TP22.1 R101.1 40.87,112.12 40.59,111.84 40.59,109.93 40.82,109.7 RB27.2
EEPROM_A2: length 7.3
  TOP w0.107: U15.3 42.59,113.75 TP20.1 42.88,113.46 R100.1 42.34,112.06 42.11,111.84 42.11,109.8 42.27,109.65 RB28.2
EFM8_ACOK: length 3.3
  TOP w0.107: RZ6.1 R31.1 128.73,156.32 U6.16
EFM8_D_ONKEY_N: length 2.5
  TOP w0.107: U6.19 v1(131.03,155.45) 131.03,154.97 TP13.1
  BOTTOM w0.107: RB63.2 v1(131.03,155.45)
EFM8_FORCE_SHUTDOWN: length 137.7
  TOP w0.107: U6.14 v1(128.65,157.32) ; U11.4 109.86,158.59 R48.2 v1(110.49,158.75)
  IN3 w0.124: v1(128.65,157.32) 128.91,157.07 128.91,140.21 128.27,139.57 128.27,133.32 130.33,131.26 130.33,128.02 131.04,127.31 131.04,123.6 132.66,121.97 134.39,121.97 136.88,119.48 136.88,116.18 141.5,111.56 145.52,111.56 149.08,107.99 149.08,102.73 151.85,99.97 151.85,97.3 152.81,96.34 152.81,78.49 v1(151.16,76.83)
  BOTTOM w0.107: v1(128.65,157.32) 128.3,157.32 127.89,157.73 127.89,160.98 127.13,161.74 111.45,161.74 110.49,160.78 v1(110.49,158.75) ; v1(151.16,76.83) 147.85,76.83 145.69,74.68 145.69,67.82 145.19,67.31 RZ204.1
EFM8_MODULE_POWER_ON: length 6.9
  TOP w0.107: U6.9 130.53,162.41 130.66,162.53 RZU3.2 130.66,163.86 U7.4 132.25,164.32 RB5.1
EFM8_P0_4: length 2.8
  TOP w0.107: TP14.1 130.3,155.22 130.53,155.45 U6.18
EFM8_PSHOLD: length 1.6
  TOP w0.107: RZ5.1 127.97,156.82 U6.15
EFM8_RST_MON: length 125.9
  TOP w0.107: U19.2 113.06,91.29 113.18,91.16 113.44,91.16 113.56,91.29 113.56,91.42 U19.1 114.83,91.68 v1(115.09,91.43) ; U6.13 127.9,157.82 RB11.2 127.86,157.58 127.64,157.35 124.66,157.35 Q2.6 124.19,157.37 123.95,157.61 v1(123.83,157.61)
  IN1 w0.124: v1(115.09,91.43) 115.47,91.05 115.47,85.34 114.83,84.71 114.83,75.18 116.61,73.41 120.04,73.41 120.8,72.64 129.06,72.64 130.3,73.89 133.88,73.89 134.62,73.15 v1(139.83,73.15)
  IN3 w0.124: v1(115.09,91.43) 115.09,96.18 113.35,97.91 113.35,102.21 118.16,107.02 118.16,110.87 119.86,112.57 119.86,122.39 122.95,125.48 122.95,132.86 124.73,134.64 124.73,141.3 125.22,141.79 125.22,147.79 125.22,151.39 124.33,152.27 124.33,157.1 v1(123.83,157.61)
  BOTTOM w0.107: RZ201.1 v1(139.83,73.15)
EFM8SB10_C2CK: length 42.5
  TOP w0.107: MCUCON1.2 156.59,162.69 156.08,163.19 156.08,166.2 151.35,170.94 136.27,170.94 134.62,169.29 134.62,159.36 134.87,159.11 RB10.2 134.39,158.6 134.16,158.37 TP16.1 133.56,158.32 U6.5
EFM8SB10_C2D: length 38.7
  TOP w0.107: U6.6 132.05,159.1 132.72,159.77 TP15.1 134.23,160.4 134.23,169.45 136.11,171.33 151.51,171.33 MCUCON1.1
ETH_WOL_EN_N: length 14.2
  BOTTOM w0.107: Q58.G 145.12,173.37 Z17.2 R1475.1 147.29,173.2 148.79,171.7 WOL1.1
ETH_WOL_EN_STATUS: length 88.6
  TOP w0.107: v3(94.36,118.49) 94.36,118.32 J1.A47
  IN3 w0.124: v3(94.36,118.49) 94.36,118.8 95.41,119.85 95.41,120.71 95.86,121.16 95.86,121.92 96.24,122.3 96.5,122.3 96.9,122.7 96.9,124.33 97.94,125.37 97.94,133.18 103.45,138.69 103.45,140.56 104.81,141.91 104.81,156.23 110.8,162.23 111.86,162.23 112.83,163.19 v1(113.41,163.19)
  BOTTOM w0.107: v1(113.41,163.19) 113.41,162.79 113.67,162.54 117.76,162.54 120.83,165.61 127.08,165.61 131.01,169.54 138.3,169.54 140.31,171.55 R1476.1 Q58.D
F1: length 71.2
  TOP w0.203: v1(133.76,69.22) 133.68,69.3 U13.42
  IN1 w0.203: v1(133.76,69.22) 133.58,69.04 133.58,64.45 134.62,63.41 134.62,62.62 137.36,59.88 137.36,53.96 135.61,52.2 135.61,39.13 142.19,32.55 142.19,27.01 143.39,24.1 149.38,18.12 149.38,16.26 149.58,16.05 v1(149.94,16.05)
  BOTTOM w0.203: v1(149.94,16.05) Z4.2 150.6,15.39 151.18,14.81 153.87,14.81 154.32,14.36 TP18.3 ; R1498.1 v1(133.76,69.22)
F2: length 80.1
  TOP w0.254: U13.30 v1(134.83,74.55)
  IN1 w0.203: v1(134.83,74.55) 135.56,73.81 140.21,73.81 140.77,73.25 140.77,65.76 139.06,64.06 139.06,59.16 137.69,57.78 137.69,53.82 135.94,52.07 135.94,39.26 142.52,32.68 142.52,27.08 143.67,24.29 150.52,17.44 150.52,16.26 150.72,16.05 v1(151.23,16.05)
  BOTTOM w0.203: TP18.2 154.82,14.5 154.13,15.19 152.35,15.19 151.87,15.67 Z3.2 v1(151.23,16.05)
  BOTTOM w0.254: v1(134.83,74.55) 134.9,74.62 R1499.1
F3: length 74.2
  TOP w0.203: v1(133.76,70.36) 133.32,70.8 U13.39
  IN1 w0.203: v1(133.76,70.36) 133.25,69.85 133.25,64.31 134.29,63.27 134.29,62.48 137.03,59.74 137.03,54.09 135.28,52.34 135.28,38.99 141.86,32.41 141.86,26.95 143.11,23.92 149.05,17.98 149.05,16.12 149.67,15.49 151.92,15.49 v1(152.48,16.05)
  BOTTOM w0.203: TP18.1 155.32,14.63 154.25,15.7 153.49,15.7 Z2.2 v1(152.48,16.05) ; R1500.1 v1(133.76,70.36)
FC_PWR_OFF: length 3.7
  BOTTOM w0.107: NGFF1.6 146.54,176.92 R212.1 R210.1
FORCE_RECOVERY_N: length 12.2
  TOP w0.107: J1.L10 57.8,134.5 56.06,136.25 51.36,136.25 50.57,137.03 50.57,137.97 50.11,138.43 RZ19.2
FORCE_RECOVERY_N_CON: length 122.7
  TOP w0.107: RZ11.1 50.19,140.72 50.59,141.11 64.71,141.11 68.13,144.54 112.78,144.54 116.57,140.75 123.65,140.75 124.56,141.66 133.17,141.66 134.7,140.13 134.7,137.87 135.86,136.7 147.65,136.7 148.18,136.17 v1(150.88,136.17)
  BOTTOM w0.107: RECOVERY1.3 155.33,126.86 154.43,127.76 154.43,134.53 CA135.1 151.65,136.18 RB64.2 v1(150.88,136.17)
FORCE_RECOVERY_N_KEY: length 15.9
  TOP w0.107: RZU6.1 Z12.2 46.96,138.44 C135.1 46.95,136.19 v1(44.83,134.07) ; RZU6.1 RZ19.1 ; RZU6.1 RZ11.2
  BOTTOM w0.107: v1(44.83,134.07) PSON3.1 PSON3.2
HDMI_DP0_TX0_N: length 36.6
  TOP w0.089: CB156.2 99.16,92.39 99.16,92.58 v1(98.95,92.79) ; J1.D52 98.41,122.36 98.3,122.47 98.3,122.88 v3(98.42,123)
  IN3 w0.094: v3(98.42,123) 98.29,122.87 98.29,122.27 98.55,122.01 98.55,121.35 99.62,120.28 99.62,119.52 99.42,119.31 99.42,115.91 98.93,115.43 98.93,101.45 99.95,100.43 99.95,97.7 100.99,96.66 100.99,92.46 100.58,92.05 99.42,92.05 99.16,92.31 99.16,92.58 v1(98.95,92.79)
HDMI_DP0_TX0_P: length 36.6
  TOP w0.089: J1.D51 97.91,122.36 98.02,122.47 98.02,122.86 v3(97.88,123) ; v1(99.66,92.79) 99.44,92.58 99.44,92.39 CB155.2
  IN3 w0.094: v3(97.88,123) 98.01,122.87 98.01,122.16 98.27,121.9 98.27,121.24 99.34,120.17 99.34,119.63 99.14,119.43 99.14,116.03 98.65,115.54 98.65,104.8 98.47,104.62 98.47,104.33 98.65,104.15 98.65,103.87 98.47,103.69 98.47,103.4 98.65,103.22 98.65,102.94 98.47,102.76 98.47,102.48 98.65,102.29 98.65,101.33 99.67,100.32 99.67,97.59 100.71,96.55 100.71,95.96 100.53,95.78 100.53,95.5 100.71,95.31 100.71,95.03 100.53,94.85 100.53,94.57 100.71,94.38 100.71,94.1 100.53,93.92 100.53,93.64 100.71,93.45 100.71,92.57 100.47,92.33 99.53,92.33 99.44,92.42 99.44,92.58 v1(99.66,92.79)
HDMI_DP0_TX1_N: length 33.5
  TOP w0.089: J1.B52 98.5,119.36 98.3,119.56 98.3,119.88 v3(98.42,120) ; CB158.2 97.1,92.42 97.1,93.11 v1(96.89,93.32)
  IN3 w0.094: v1(96.89,93.32) 97.1,93.11 97.1,92.28 97.36,92.02 98.27,92.02 98.53,92.28 98.53,100.07 97.66,100.94 97.66,116.47 98.51,117.31 98.51,118.77 98.29,118.98 98.29,119.87 v3(98.42,120)
HDMI_DP0_TX1_P: length 32.9
  TOP w0.089: CB157.2 97.38,92.37 97.38,93.11 v1(97.6,93.32) ; v3(97.88,120) 98.02,119.86 98.02,119.55 97.83,119.36 J1.B51
  IN3 w0.094: v1(97.6,93.32) 97.38,93.11 97.38,92.4 97.48,92.3 98.15,92.3 98.25,92.4 98.25,99.96 97.38,100.82 97.38,101.73 97.2,101.92 97.2,102.2 97.38,102.38 97.38,102.66 97.2,102.85 97.2,103.13 97.38,103.31 97.38,116.59 98.23,117.43 98.23,118.65 98.01,118.87 98.01,119.87 v3(97.88,120)
HDMI_DP0_TX2_N: length 28.7
  TOP w0.089: CB160.2 95.55,92.14 95.55,93.18 96.06,93.69 96.06,94.35 v1(95.84,94.56) ; J1.A50 96.75,117.86 96.9,118.01 96.9,118.38 v3(96.78,118.5)
  IN3 w0.094: v3(96.78,118.5) 96.91,118.37 96.91,117.76 95.55,116.41 95.55,104.51 96.06,104 96.06,94.78 v1(95.84,94.56)
HDMI_DP0_TX2_P: length 28.7
  TOP w0.089: CB159.2 95.83,92.14 95.83,93.06 96.34,93.57 96.34,94.35 v1(96.56,94.56) ; J1.A51 97.33,117.86 97.18,118.01 97.18,118.36 v3(97.32,118.5)
  IN3 w0.094: v1(96.56,94.56) 96.34,94.78 96.34,104.11 95.83,104.62 95.83,116.29 97.19,117.65 97.19,118.37 v3(97.32,118.5)
HDMI_DP0_TX3_N: length 32.8
  TOP w0.089: v1(94.06,93.07) 94.28,92.85 94.28,92.14 CB162.2 ; v3(96.78,121.5) 96.8,121.5 96.9,121.4 96.9,121.02 96.74,120.86 J1.C50
  IN3 w0.094: v3(96.78,121.5) 96.8,121.5 96.91,121.39 96.91,120.88 96.57,120.54 96.57,119.83 95.58,118.84 95.58,118.03 93.83,116.29 93.83,108.2 94.22,107.82 94.22,100.61 94.95,99.88 94.95,94.39 94.28,93.72 94.28,93.29 v1(94.06,93.07)
HDMI_DP0_TX3_P: length 32.8
  TOP w0.089: J1.C51 97.34,120.86 97.18,121.02 97.18,121.36 v3(97.32,121.5) ; CB161.2 94.56,92.14 94.56,92.86 v1(94.77,93.07)
  IN3 w0.094: v1(94.77,93.07) 94.56,93.29 94.56,93.6 95.22,94.27 95.22,100 94.5,100.73 94.5,107.93 94.11,108.32 94.11,116.17 95.86,117.92 95.86,118.72 96.85,119.71 96.85,120.42 97.19,120.76 97.19,121.37 v3(97.32,121.5)
HDMI_GND: length 14
  TOP w0.508: 108.21,44.45 HDMI1.X3 ; HDMI1.X3 109.61,43.05 ; HDMI1.X3 109.61,45.85 ; 93.72,44.45 HDMI1.X1 ; HDMI1.X1 95.11,45.85 ; HDMI1.X1 95.11,43.05 ; HDMI1.X1 96.51,44.45 ; HDMI1.X2 103.76,41.15 ; HDMI1.X2 102.36,42.55 ; HDMI1.X2 100.97,41.15
HMCU_SCL_A: length 2.8
  TOP w0.107: U66.7 90.83,86.53 90.78,86.49 90.2,86.49 89.31,87.38 R535.2
HMCU_SDA_A: length 2.4
  TOP w0.107: R536.2 89.46,86.23 89.56,86.13 U66.8
HPO_L: length 1.5
  BOTTOM w0.381: RZ686.2 148.62,155.42 148.72,155.32 FB41.1
HPO_R: length 1.5
  BOTTOM w0.381: FB40.2 148.72,153.42 148.56,153.26 RZ685.2
HUB_RESET#: length 7.8
  TOP w0.107: U20.41 77.49,69.35 76.88,69.96 76.88,71.35 76.28,71.96 76.28,72.38 C60.1 75.02,72.5 R164.2 RZ76.1 73.38,72.49 73.2,72.31 R162.1
HUB_XTAL1: length 9.5
  TOP w0.107: X1.1 95.29,65.7 95.07,65.48 93.49,65.48 C58.1 92.48,66.48 R159.2 91.56,66.15 U20.9
HUB_XTAL2: length 4.2
  TOP w0.107: RZ82.2 90.91,66.55 U20.10
HUB_XTAL2_R: length 3.6
  TOP w0.107: X1.3 94.04,67.35 C57.1 92.51,67.02 R159.1 91.3,67.61 RZ82.1
I2C_GP1_CLK: length 25.4
  TOP w0.107: U15.6 42.55,121.06 v1(42.55,122.3) TP21.1 R92.2 ; J1.K5 v1(53.5,132.08)
  BOTTOM w0.107: v1(53.5,132.08) 53.5,132.43 53.09,132.84 47.5,132.84 46.44,131.78 43.57,131.78 41.94,130.15 41.94,122.91 v1(42.55,122.3)
I2C_GP1_DAT: length 31.2
  TOP w0.107: U15.5 43.81,121.06 v1(43.81,122.3) TP19.1 R93.2 ; J1.L8 56,133.99 55.83,134.16 v1(55.37,134.16)
  BOTTOM w0.107: v1(55.37,134.16) 47.98,134.16 46.01,132.19 43.4,132.19 41.53,130.32 41.53,122.56 42.29,121.79 43.31,121.79 v1(43.81,122.3)
I2C_GP2_CLK: length 162.5
  TOP w0.107: RZ91.1 126.11,65.66 126.49,66.04 v1(126.49,67.69) ; v1(146.38,106.93) 145.97,106.93 145,107.91 RZU22.2 ; J1.J61 v1(106.5,130.52) ; J14.87 v1(115.5,163.76)
  IN1 w0.124: v1(106.5,130.52) 107.02,131.04 128.35,131.04 v1(128.51,130.87)
  IN3 w0.124: v1(126.49,67.69) 126.98,67.21 128.46,67.21 129.64,68.39 136.13,68.39 138.38,70.64 138.38,73.31 139.22,74.14 141.19,74.14 143.41,76.36 149.06,76.36 151.87,79.17 151.87,96.07 150.99,96.95 150.99,99.54 148.22,102.31 148.22,105.98 147.57,106.63 146.68,106.63 v1(146.38,106.93) 142.64,110.67 141.17,110.67 136.02,115.82 136.02,119.1 134.04,121.08 132.34,121.08 130.18,123.24 130.18,126.95 128.51,128.62 v1(128.51,130.87) ; v1(115.5,163.76) 115.09,163.35 115.09,160.83 107.08,152.82 107.08,138.8 106.49,138.21 106.49,136.84 106.08,136.43 106.08,134.05 106.27,133.86 106.27,130.75 v1(106.5,130.52)
I2C_GP2_CLK_3V3: length 148.2
  TOP w0.107: RB57.1 129.03,65.79 130.05,65.79 v1(130.25,65.99) 130.56,66.3 U13.48 ; RZU32.2 v1(62.94,71.45)
  IN1 w0.124: v1(106.96,69.85) 108.2,69.85 110.49,72.14 115.09,72.14 116.46,70.77 127.74,70.77 129.69,68.81 129.69,66.55 v1(130.25,65.99)
  IN3 w0.124: v1(106.96,69.85) 107.29,69.52 107.29,65.61 104.62,62.94 96.84,62.94 91.56,57.66 86.29,57.66 85.56,56.93 82.98,56.93 82.07,56.02 77.67,56.02 75.4,58.29 73.66,58.29 71.86,60.09 70.61,60.09 63.7,67.01 63.7,70.69 v1(62.94,71.45) 61.07,73.32 49.31,73.32 46.07,76.56 46.07,85.62 47.04,86.59 49.05,86.59 50.04,87.58 50.04,92.58 50.62,93.17 50.62,100 49.91,100.71 49.91,105.25 49.1,106.06 v1(49.1,106.81)
  BOTTOM w0.107: RB57.1 130.12,65.86 v1(130.25,65.99) ; RZU44.2 v1(49.1,106.81)
I2C_GP2_DAT: length 160.3
  TOP w0.107: v1(116.05,163.42) 116,163.48 J14.89 ; J1.K61 v1(106.7,132.02) ; v1(146.41,107.6) 146.14,107.86 RZU23.2 ; RZ86.1 v1(125.7,67.67)
  IN1 w0.124: v1(106.7,132.02) 107.22,132.54 109.86,132.54 110.92,131.47 128.58,131.47 v1(129.17,130.87)
  IN3 w0.124: v1(116.05,163.42) 116.05,161.19 107.51,152.64 107.51,138.62 106.92,138.03 106.92,132.24 v1(106.7,132.02) ; v1(129.17,130.87) 129.17,128.56 130.61,127.13 130.61,123.42 132.52,121.51 134.22,121.51 136.45,119.28 136.45,116 141.32,111.13 142.87,111.13 v1(146.41,107.6) 146.94,107.06 147.75,107.06 148.65,106.16 148.65,102.48 151.42,99.72 151.42,97.12 152.3,96.24 152.3,78.99 149.23,75.93 143.59,75.93 141.37,73.71 139.4,73.71 138.81,73.13 138.81,70.46 136.31,67.96 129.82,67.96 128.64,66.78 126.59,66.78 v1(125.7,67.67)
I2C_GP2_DAT_3V3: length 150.5
  TOP w0.107: U13.47 130.46,66.8 v1(130.25,67.01) RB56.1 ; RZU33.2 62.41,70.56 v1(62.97,70.56)
  IN1 w0.124: v1(130.25,67.01) 130.25,68.86 127.91,71.19 116.63,71.19 115.26,72.57 110.31,72.57 108.36,70.61 v1(107.47,70.61)
  IN3 w0.124: v1(49.1,107.95) 48.54,107.39 48.54,106.01 49.48,105.07 49.48,100.53 50.19,99.82 50.19,93.34 49.61,92.76 49.61,87.76 48.87,87.02 46.86,87.02 45.64,85.8 45.64,76.38 49.13,72.9 60.73,72.9 62.97,70.66 v1(62.97,70.56) 63.05,70.56 63.27,70.33 63.27,66.83 70.44,59.66 71.68,59.66 73.48,57.86 75.22,57.86 77.5,55.59 82.25,55.59 83.16,56.5 85.74,56.5 86.47,57.23 91.73,57.23 97.02,62.51 104.8,62.51 107.72,65.43 107.72,70.36 v1(107.47,70.61)
  BOTTOM w0.107: RB56.1 v1(130.25,67.01) ; RZU43.2 v1(49.1,107.95)
I2C_GP3_CLK: length 48.7
  TOP w0.107: J1.F53 99.72,125.58 v1(99.72,126.11) ; R242.1 105.16,137.97 v1(104.72,137.54) ; J14.75 v1(112.5,161.31)
  IN3 w0.124: v1(99.72,126.11) 99.74,126.14 99.74,126.87 99.49,127.12 99.49,129.97 98.93,130.53 98.93,132.95 102.99,137.01 104.19,137.01 v1(104.72,137.54) 105.01,137.82 105.01,140.89 105.66,141.55 105.66,155.88 111.1,161.31 v1(112.5,161.31)
I2C_GP3_DAT: length 51.8
  TOP w0.107: J14.77 113,164.2 112.93,164.13 112.93,161.65 113.16,161.42 v1(113.16,161.29) ; J1.E53 99.2,123.96 v1(99.2,124.52) ; R243.1 v1(104.01,137.54)
  IN3 w0.124: v1(113.16,161.29) 113.16,161.54 112.9,161.8 110.98,161.8 105.23,156.05 105.23,141.73 104.58,141.07 104.58,138.1 v1(104.01,137.54) 102.91,137.54 98.5,133.13 98.5,130.35 99.06,129.79 99.06,126.75 99.3,126.51 99.3,124.62 v1(99.2,124.52)
I2C_GP9_CLK: length 115.8
  TOP w0.107: v1(99.82,118.49) 99.3,117.97 J1.A53 ; J14.105 v1(120,162.81)
  IN1 w0.124: v1(99.82,118.49) 100.44,119.11 123.55,119.11 126.67,122.23 133.07,122.23 135.94,125.09 142.6,125.09 144.85,127.35 144.85,132.03 v1(147.57,134.75)
  IN3 w0.124: v1(137.77,151.13) 137.77,151.1 135.91,149.25 135.91,138.69 137.39,137.21 145.75,137.21 147.57,135.38 v1(147.57,134.75)
  BOTTOM w0.107: RZ158.1 137.79,151.1 v1(137.77,151.13) 137.77,151.54 TP29.1 135.73,153.58 135.73,160.49 134.06,162.15 120.9,162.15 120.24,162.81 v1(120,162.81) ; RZU40.2 v1(147.57,134.75)
I2C_GP9_DAT: length 118
  TOP w0.107: J14.107 v1(120.5,163.32) ; J1.C53 v1(99.3,121.52)
  IN1 w0.124: v1(99.3,121.52) 99.3,120.89 100.65,119.54 123.37,119.54 126.49,122.66 132.9,122.66 135.76,125.52 142.42,125.52 144.42,127.53 144.42,132.23 146.43,134.24 v1(146.43,134.75)
  IN3 w0.124: v1(146.43,134.75) 146.43,135.81 145.47,136.78 137.21,136.78 135.48,138.51 135.48,149.45 137.8,151.76 138.4,151.76 138.94,151.23 v1(138.94,151.13)
  BOTTOM w0.107: RZ157.1 v1(138.94,151.13) 138.68,151.38 TP28.1 136.14,154.44 136.14,160.66 134.23,162.57 124.04,162.57 121.26,162.57 v1(120.5,163.32) ; RZU41.2 v1(146.43,134.75)
I2C_INT_CCG4: length 16.7
  TOP w0.107: J1.E56 102.2,124.06 102.2,124.47 v1(102.25,124.52) ; v1(114.58,123.27) 114.6,123.27 115.29,122.58 RB24.1 116.93,122.58 Q59.S
  IN1 w0.124: v1(114.58,123.27) 111.43,123.27 110.87,123.82 102.49,123.82 102.25,124.06 v1(102.25,124.52)
I2C_SCL_CDC: length 3.6
  TOP w0.107: R124.2 v1(138.18,148.84)
  BOTTOM w0.107: RZ158.2 137.79,149.22 v1(138.18,148.84) 138.68,148.34 139.32,148.34 139.55,148.1 U16.38
I2C_SDA_CDC: length 2.9
  TOP w0.107: v1(139.32,148.84) 139.24,148.92 R123.2
  BOTTOM w0.107: U16.39 139.95,148.21 v1(139.32,148.84) 138.94,149.22 RZ157.2
I2S1_DIN: length 94.6
  TOP w0.107: v1(131.32,146.56) 127.02,146.56 122,141.54 116.88,141.54 113.05,145.37 65.15,145.37 61.94,142.16 v1(57.05,142.16) ; J1.H8 56.01,128.55 56.01,128.95 v1(55.94,129.02)
  IN3 w0.124: v1(55.94,129.02) 56.01,129.09 56.01,129.77 56.44,130.2 56.44,130.96 57.25,131.78 57.25,141.96 v1(57.05,142.16)
  BOTTOM w0.107: RZ163.1 v1(131.32,146.56)
I2S1_DIN_CDC: length 5.9
  BOTTOM w0.107: RZ163.2 135.13,146.56 135.34,146.34 C912.1 136.53,146.05 TP27.1 136.91,146.18 U16.34
I2S1_DOUT: length 101.3
  TOP w0.107: v1(131.32,145.41) 126.42,145.41 122.16,141.16 116.72,141.16 112.89,144.99 65.31,144.99 61.98,141.66 v1(58.19,141.66) ; J1.C7 v1(55.1,121.52)
  IN3 w0.124: v1(58.19,141.66) 58.19,141.22 58.12,141.15 58.12,130.43 57.18,129.49 57.18,128.73 56.9,128.45 56.9,127.23 56.46,126.8 56.46,124.36 55.92,123.82 55.31,123.82 54.88,123.39 54.88,121.74 v1(55.1,121.52)
  BOTTOM w0.107: RZ165.1 v1(131.32,145.41)
I2S1_DOUT_CDC: length 6.6
  BOTTOM w0.107: RZ165.2 133.07,145.26 133.27,145.47 135.08,145.47 135.34,145.2 C913.1 136.4,144.91 TP26.1 137.78,145.78 U16.33
I2S1_FS: length 101
  TOP w0.107: v1(131.32,147.7) 127.61,147.7 121.84,141.93 117.04,141.93 113.21,145.76 64.99,145.76 61.78,142.55 58.82,142.55 v1(58.7,142.67) ; J1.D8 56.17,122.39 56.17,122.99 v1(56.12,123.04)
  IN3 w0.124: v1(56.12,123.04) 56.12,123.19 57.34,124.41 57.34,125.13 59.51,127.3 59.51,127.69 58.55,128.65 58.55,140.64 58.7,140.79 v1(58.7,142.67)
  BOTTOM w0.107: RZ161.1 v1(131.32,147.7)
I2S1_FS_CDC: length 6.2
  BOTTOM w0.107: RZ161.2 133.2,147.83 135.13,147.83 135.34,147.61 C914.1 TP25.1 137.26,146.58 U16.35
I2S1_SCLK: length 84.2
  TOP w0.107: v1(61.98,143.84) 64.29,146.15 114.31,146.15 118.16,150 130.29,150 v1(131.32,148.97) ; v3(61.98,133.5) 61.98,133.04 J1.L14
  IN3 w0.124: v3(61.98,133.5) v1(61.98,143.84)
  BOTTOM w0.107: RZ159.1 v1(131.32,148.97)
I2S1_SCLK_CDC: length 6.4
  BOTTOM w0.107: RZ159.2 133.13,149.03 135.06,149.03 135.34,148.76 C915.1 TP24.1 138.14,146.98 U16.36
I2S4_DIN: length 34.3
  TOP w0.107: J1.J59 v1(104.7,130.52)
  IN1 w0.124: v1(134.87,132.08) 134.44,132.51 131.5,132.51 130.88,131.9 111.1,131.9 110.02,132.98 106.97,132.98 106.25,132.26 106.25,131.7 105.74,131.19 105.41,131.19 104.74,130.52 v1(104.7,130.52)
  BOTTOM w0.107: WIFI1.12 134.99,131.97 v1(134.87,132.08)
I2S4_DOUT: length 34.1
  TOP w0.107: J1.K59 v1(104.9,132.02)
  IN1 w0.124: v1(135.49,132.08) 134.63,132.94 131.32,132.94 130.71,132.33 111.28,132.33 110.2,133.41 106.7,133.41 105.74,132.45 105.17,132.45 104.9,132.18 v1(104.9,132.02)
  BOTTOM w0.107: WIFI1.14 v1(135.49,132.08)
I2S4_FS: length 35
  TOP w0.107: J1.C60 v1(105.6,121.52)
  IN1 w0.124: v1(105.6,121.52) 106.16,122.07 111.64,122.07 111.89,122.32 115.06,122.32 117.6,124.86 117.99,124.86 120.52,127.38 124.99,127.38 125.5,126.88 131.96,126.88 v1(134.75,129.67)
  BOTTOM w0.107: WIFI1.10 134.49,129.93 v1(134.75,129.67)
I2S4_SCLK: length 35.2
  TOP w0.107: J1.C59 v1(104.7,121.52)
  IN1 w0.124: v1(104.7,121.52) 105.69,122.5 111.46,122.5 111.71,122.75 114.88,122.75 117.42,125.29 117.81,125.29 120.34,127.81 125.17,127.81 125.67,127.31 131.78,127.31 134.11,129.64 v1(134.11,129.67)
  BOTTOM w0.107: WIFI1.8 133.99,129.79 v1(134.11,129.67)
I210_JTAG_CLK1: length 2
  BOTTOM w0.107: U41.19 21.81,38.13 21.21,38.73 R278.1
I210_JTAG_TDI1: length 2.5
  TOP w0.107: R280.1 27.18,37.64 26.9,37.92 v1(26.9,38.3)
  BOTTOM w0.107: U41.29 26.81,38.22 v1(26.9,38.3) 26.92,38.33 R279.1
I210_JTAG_TDO1: length 1.6
  BOTTOM w0.107: U41.4 18.66,30.64 18.55,30.54 R276.1
I210_JTAG_TMS1: length 2.1
  BOTTOM w0.107: U41.18 21.31,38 20.57,38.73 R277.1
I2101 SDP0: length 2.8
  BOTTOM w0.107: U41.63 21.31,27.59 20.73,27 20.12,27 19.89,26.77 RA132.1
I2101 SDP1: length 2.3
  BOTTOM w0.107: RA130.1 21.16,26.62 22.31,27.77 U41.61
I2101 SDP2: length 2.4
  BOTTOM w0.107: RA131.1 20.56,26.5 21.81,27.75 U41.62
I2101 SDP3: length 2.3
  BOTTOM w0.107: U41.60 22.81,27.89 21.79,26.87 RA129.1
I2101_RSET: length 1.9
  TOP w0.254: v1(29.97,28.96) 29.9,28.88 R273.2
  BOTTOM w0.229: U41.48 29.79,29.14 v1(29.97,28.96)
I2101_SMB_ALERT#: length 1.6
  BOTTOM w0.107: RA67.2 30.35,35.94 30.06,35.64 U41.35
I2101_SMCLK: length 1.7
  BOTTOM w0.107: U41.34 29.92,36.14 30.35,36.58 RA66.2
I2101_SMDATA: length 1.5
  BOTTOM w0.107: U41.36 30.19,35.14 30.35,35.31 RA68.2
I2102_RSET: length 1.9
  TOP w0.254: R294.2 45.9,26.04 v1(46.74,26.04)
  BOTTOM w0.229: v1(46.74,26.04) 46.55,26.22 U43.48
I2102_SMB_ALERT#: length 1.7
  BOTTOM w0.107: RA81.2 46.86,33.15 46.44,32.72 U43.35
I2102_SMCLK: length 1.7
  BOTTOM w0.107: U43.34 46.43,33.22 46.99,33.78 RA74.2
I2102_SMDATA: length 1.6
  BOTTOM w0.107: RA88.2 46.9,32.51 46.61,32.22 U43.36
I2103_RSET: length 1.9
  TOP w0.254: v1(65.02,26.04) 64.19,26.04 R321.2
  BOTTOM w0.229: v1(65.02,26.04) 64.84,26.22 U45.48
I2103_SMB_ALERT#: length 1.7
  BOTTOM w0.107: U45.35 64.73,32.72 65.15,33.15 RA80.2
I2103_SMCLK: length 1.7
  BOTTOM w0.107: RA73.2 65.28,33.78 64.72,33.22 U45.34
I2103_SMDATA: length 1.6
  BOTTOM w0.107: U45.36 64.9,32.22 65.19,32.51 RA87.2
I2104_RSET: length 1.9
  TOP w0.254: v1(83.31,26.04) 82.47,26.04 R342.2
  BOTTOM w0.254: U47.48 82.85,26.22 83.03,26.04 v1(83.31,26.04)
I2104_SMB_ALERT#: length 1.7
  BOTTOM w0.107: U47.35 83.14,32.72 83.57,33.15 RA79.2
I2104_SMCLK: length 1.7
  BOTTOM w0.107: RA72.2 83.69,33.78 83.13,33.22 U47.34
I2104_SMDATA: length 1.6
  BOTTOM w0.107: RA86.2 83.41,32.51 83.12,32.22 U47.36
I2105_RSET: length 1.9
  TOP w0.254: R369.2 100.76,26.04 v1(101.6,26.04)
  BOTTOM w0.107: U49.48 101.41,26.22 v1(101.6,26.04)
I2105_SMB_ALERT#: length 1.7
  BOTTOM w0.107: U49.35 101.3,32.72 101.73,33.15 RA78.2
I2105_SMCLK: length 1.7
  BOTTOM w0.107: U49.34 101.29,33.22 101.85,33.78 RA71.2
I2105_SMDATA: length 1.6
  BOTTOM w0.107: RA85.2 101.76,32.51 101.47,32.22 U49.36
I2106_RSET: length 1.9
  TOP w0.254: R393.2 119.05,26.04 v1(119.89,26.04)
  BOTTOM w0.229: v1(119.89,26.04) 119.7,26.22 U51.48
I2106_SMB_ALERT#: length 1.7
  BOTTOM w0.107: RA77.2 120.02,33.15 119.59,32.72 U51.35
I2106_SMCLK: length 1.7
  BOTTOM w0.107: U51.34 119.58,33.22 120.14,33.78 RA70.2
I2106_SMDATA: length 1.6
  BOTTOM w0.107: U51.36 119.76,32.22 120.05,32.51 RA84.2
I2107_RSET: length 1.9
  TOP w0.254: v1(138.18,26.42) 137.34,26.42 R417.2
  BOTTOM w0.229: v1(138.18,26.42) 137.99,26.6 U53.48
I2107_SMB_ALERT#: length 1.7
  BOTTOM w0.107: U53.35 137.88,33.1 138.3,33.53 RA75.2
I2107_SMCLK: length 1.7
  BOTTOM w0.107: RA69.2 138.43,34.16 137.87,33.6 U53.34
I2107_SMDATA: length 1.6
  BOTTOM w0.107: RA82.2 138.34,32.89 138.05,32.6 U53.36
I2108_RSET: length 1.9
  TOP w0.254: v1(135,54.23) 135,53.39 R441.2
  BOTTOM w0.229: U55.48 134.81,54.04 v1(135,54.23)
I2108_SMB_ALERT#: length 1.5
  BOTTOM w0.107: U55.35 128.31,54.23 127.97,54.58 RA56.2
I2108_SMCLK: length 1.6
  BOTTOM w0.107: RA57.2 127.33,54.59 127.81,54.1 U55.34
I2108_SMDATA: length 1.4
  BOTTOM w0.107: U55.36 128.81,54.36 128.6,54.57 RA55.2
IGN: length 5.1
  TOP w0.508: 11.89,175.95 DC_IN1.2 11.89,178.1 11.4,178.59 FB38.1
IN1P: length 4.9
  BOTTOM w0.381: C898.1 153.92,145.8 154.23,146.1 156.33,146.1 AUDIO1.1
IN2P: length 2.5
  BOTTOM w0.381: C899.1 154.18,144.65 154.62,145.1 AUDIO1.2
INTR_ISP1: length 2.8
  TOP w0.107: U13.38 133.55,71.3 v1(133.76,71.5)
  BOTTOM w0.107: R1505.1 v1(133.76,71.5)
ISO12_REF: length 6.7
  TOP w0.508: 53.61,197.56 NMEA0183.1 54.55,196.62 ; 51.64,188.85 51.64,189.83 ; 51.64,188.85 50.66,188.85 ; 51.64,188.85 52.62,188.85 ; 43.55,196.62 NMEA2000.8 44.49,197.56
  vias: v1(43.31,192.66) v1(44.2,192.66) v1(45.09,192.66) v1(45.85,192.66)
ISO_+V12S: length 11.5
  IN1 w0.508: 50.59,186.31 U39.6 ; U39.6 52.7,186.31 ; U39.6 51.64,185.25
  IN2 w0.508: 51.64,185.25 U39.6 ; U39.6 52.7,186.31 ; U39.6 50.59,186.31
  IN3 w0.508: 50.59,186.31 U39.6 ; U39.6 51.64,185.25 ; U39.6 52.7,186.31
  BOTTOM w0.508: 50.97,186.31 U39.6 ; U39.6 51.64,185.64 ; U39.6 52.32,186.31
  vias: v1(46.35,185.55) v1(46.35,184.91) v1(47.12,185.55) v1(47.12,184.91) v1(57.02,185.29) v1(57.78,185.29) v1(58.55,185.29)
ISO_GND: length 21
  TOP w0.381: v1(90.17,192.91) D9.8 D9.3 v1(90.17,190.37)
  TOP w0.508: R253.2 63.4,187.99 v1(63.12,187.71) ; U24.15 87.02,190.12 86.83,190.31 CA1.2 v1(87.5,191.26) ; U24.9 94.64,190.02 v1(95.12,190.5) ; U36.5 66.92,187.59 v1(66.67,187.83)
  BOTTOM w0.381: v1(90.17,192.91) D9.8 D9.3 v1(90.17,190.37)
  BOTTOM w0.508: v1(93.51,191.77) CA118.2 93.51,190.26 93.37,190.12 U26.15 ; U26.9 85.75,189.97 v1(85.22,190.5) ; v1(66.67,187.83) 66.65,187.86 R257.2 ; 77.26,188.77 U27.7 ; U27.7 77.93,189.44 ; U27.7 78.6,188.77 ; v1(63.12,187.71) U38.5
  vias: v1(25.15,199.26) v1(29.81,199.26) v1(32.35,199.26) v1(34.89,199.26) v1(37.43,199.26) v1(39.97,199.26) v1(42.51,199.26) v1(45.05,199.26) v1(47.59,199.26) v1(50.13,199.26) v1(55.21,199.26) v1(57.75,199.26) v1(60.29,199.26) v1(62.83,199.26) v1(65.37,199.26) v1(67.91,199.26) v1(69.6,186.06) v1(69.85,191.52) v1(70.23,186.06) v1(70.45,199.26) v1(70.74,191.52) v1(71.5,191.52) v1(72.26,191.52) v1(72.99,199.26) v1(78.07,199.26) v1(80.61,199.26) v1(83.15,199.26) v1(85.69,199.26) v1(88.23,199.26) v1(90.77,199.26) v1(93.31,199.26) v1(95.85,199.26) v1(98.39,199.26)
ISO_RX1: length 9.2
  TOP w0.254: U24.12 90.83,190.22 90.67,190.38 D9.4 D9.7 90.67,196.12 UART1.9
ISO_RX2: length 11.1
  TOP w0.254: U24.11 92.1,189.84 91.17,190.77 D9.5 D9.6 91.17,195.56 v1(91.31,195.71)
  IN3 w0.254: v1(91.31,195.71) 90.03,195.71 UART1.7
ISO_RX3: length 12.6
  BOTTOM w0.254: UART1.5 84.14,195.51 85.98,193.68 88.9,193.68 89.67,192.9 D10.7 D10.4 89.67,190.38 89.56,190.27 U26.12
ISO_RX4: length 15
  BOTTOM w0.254: UART1.3 84.69,193.04 88.66,193.04 89.17,192.53 D10.6 D10.5 89.17,190.64 88.29,189.76 U26.11
ISO_TX1: length 13
  TOP w0.254: v1(89.03,195.71) 89.17,195.56 D9.10 D9.1 89.17,190.64 88.29,189.76 U24.14
  IN1 w0.254: v1(89.03,195.71) 89.64,196.32 92.87,196.32 UART1.10
ISO_TX2: length 8.8
  TOP w0.254: U24.13 89.56,190.27 89.67,190.38 D9.2 D9.9 89.67,197.12 UART1.8
ISO_TX3: length 12.4
  BOTTOM w0.254: U26.14 92.1,189.84 91.17,190.77 D10.1 D10.10 91.17,193.69 89.92,194.94 87.63,194.94 86.14,196.43 UART1.6
ISO_TX4: length 14.7
  TOP w0.254: UART1.4 84.03,195.71 v1(85.34,195.71)
  BOTTOM w0.254: v1(85.34,195.71) 86.74,194.31 89.66,194.31 90.67,193.3 D10.9 D10.2 90.67,190.38 90.83,190.22 U26.13
JD1: length 14.8
  TOP w0.254: v1(151.38,148.08) 151,148.08 150.5,148.59 150.5,150.24 v1(148.84,151.89)
  IN3 w0.254: v1(145.41,145.11) 147.52,145.11 150.5,148.08 v1(151.38,148.08)
  BOTTOM w0.203: v1(145.41,145.11) 145.24,145.11 145.11,144.98 U16.6
  BOTTOM w0.254: RZ160.1 v1(151.38,148.08) ; RZU37.1 v1(148.84,151.89)
JD2: length 14.7
  TOP w0.254: v1(148.84,150.75) 149.86,149.73 149.86,148.08 151,146.94 v1(151.38,146.94)
  IN3 w0.254: v1(145.67,144.15) 146.05,144.53 147.96,144.53 150.37,146.94 v1(151.38,146.94)
  BOTTOM w0.203: v1(145.67,144.15) 145.63,144.18 U16.8
  BOTTOM w0.254: RZU39.2 v1(148.84,150.75) ; RZ162.2 v1(151.38,146.94)
JTAG_TCK: length 22
  TOP w0.107: J1.A60 106.18,117.28 106.91,116.99 113.01,116.99 114.25,118.24 TP33.1 R145.1 115.98,118.84 116.21,119.08 119.41,119.08 120.65,120.32 120.65,122.05 v1(121.67,123.06)
  BOTTOM w0.107: J4.4 121.28,122.68 v1(121.67,123.06)
JTAG_TDI: length 29.1
  TOP w0.107: J1.B60 v1(105.8,120.02)
  BOTTOM w0.107: J4.8 TP31.1 R143.2 127.03,120.4 126.73,120.1 111.61,120.1 111.31,120.4 106.18,120.4 v1(105.8,120.02)
JTAG_TDO: length 26.3
  TOP w0.107: J1.D58 v1(104,123.02)
  BOTTOM w0.107: v1(104,123.02) 104.59,122.43 111,122.43 115.82,127.25 122.05,127.25 122.81,126.49 J4.6 125.73,126.49 TP32.1 R142.2
JTAG_TMS: length 20.9
  TOP w0.107: J1.E58 v1(103.8,124.52)
  BOTTOM w0.107: v1(103.8,124.52) 103.55,124.27 103.55,122.68 104.18,122.05 111.25,122.05 113.74,124.54 116.33,124.54 116.43,124.64 R141.2 TP34.1 117.86,125.22 J4.2
JTAG_TRST_N: length 1.5
  TOP w0.107: J1.G61 v1(106.5,127.52)
  BOTTOM w0.107: TP6.1 106.55,127.47 v1(106.5,127.52)
