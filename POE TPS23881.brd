# Allegro board POE TPS23881.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#2180  -  []  131.97 141.78 270 top
NOREF#2181  -  []  89 107.24 270 top
NOREF#2182  -  []  107.43 36.63 0 top
NOREF#2183  -  []  142.65 133.35 0 top
NOREF#2184  -  []  126.44 159.84 0 top
NOREF#2185  -  []  109.04 37.39 0 top
NOREF#2186  -  []  22.81 39.87 90 top
NOREF#2187  -  []  57.59 113.06 90 top
NOREF#2188  -  []  54.53 56.31 270 top
NOREF#2189  -  []  109.91 35.51 90 top
NOREF#2190  -  []  72.16 53.85 0 top
NOREF#2191  -  []  140.03 28.08 270 top
NOREF#2192  -  []  70.94 29.71 0 top
NOREF#2193  -  []  55.62 73.14 90 top
NOREF#2194  -  []  83.9 33.92 0 top
NOREF#2195  -  []  50.44 99.31 270 top
NOREF#2196  -  []  95.87 91.39 0 top
NOREF#2197  -  []  13.03 108 0 top
NOREF#2198  -  []  54.56 40.94 0 top
NOREF#2199  -  []  147.45 130.81 270 top
NOREF#2200  -  []  102.24 25.78 90 top
NOREF#2201  -  []  54.78 150.75 0 top
NOREF#2202  -  []  126.9 159.13 0 top
NOREF#2203  -  []  137.25 120.42 0 top
NOREF#2204  -  []  71.06 25.98 0 top
NOREF#2205  -  []  136.6 18.72 0 top
NOREF#2206  -  []  59.39 25.67 90 top
NOREF#2207  -  []  44.52 115.27 90 top
NOREF#2208  -  []  54.41 58.6 270 top
NOREF#2209  -  []  54.1 113.07 270 top
NOREF#2210  -  []  151.59 146.51 90 top
NOREF#2211  -  []  135.24 44.7 0 top
NOREF#2212  -  []  96.22 17.09 90 top
NOREF#2213  -  []  126.44 155.88 270 top
NOREF#2214  -  []  56.16 78.16 270 top
NOREF#2215  -  []  134.37 146.94 0 top
NOREF#2216  -  []  97.78 36.63 0 top
NOREF#2217  -  []  36.56 31.37 0 top
NOREF#2218  -  []  124.41 154.74 270 top
NOREF#2219  -  []  45.45 29.21 0 top
NOREF#2220  -  []  151.08 70.03 270 top
NOREF#2221  -  []  20.47 22.1 0 top
NOREF#2222  -  []  93.21 23.8 0 top
NOREF#2223  -  []  134.37 54.98 90 top
NOREF#2224  -  []  39.45 67.61 270 top
NOREF#2225  -  []  64.39 176.05 90 top
NOREF#2226  -  []  142.09 98.63 90 top
NOREF#2227  -  []  81.97 26.42 0 top
NOREF#2228  -  []  146.81 129.79 90 top
NOREF#2229  -  []  139.37 30.68 90 top
NOREF#2230  -  []  66.04 85.09 270 top
NOREF#2231  -  []  46.3 71.7 90 top
NOREF#2232  -  []  125.88 58.13 90 top
NOREF#2233  -  []  144.3 94.89 90 top
NOREF#2234  -  []  88.76 33.48 90 top
NOREF#2235  -  []  86.11 26.29 0 top
NOREF#2236  -  []  116.41 17.09 90 top
NOREF#2237  -  []  114.99 135.31 270 top
NOREF#2238  -  []  134.06 69.93 0 top
NOREF#2239  -  []  17.69 35.2 0 top
NOREF#2240  -  []  50.52 48.08 0 top
NOREF#2241  -  []  140.03 27.44 0 top
NOREF#2242  -  []  110.22 25.22 90 top
NOREF#2243  -  []  134.95 106.1 270 top
NOREF#2244  -  []  126.9 160.27 0 top
NOREF#2245  -  []  126.37 0.56 90 top
NOREF#2246  -  []  127.97 31.13 0 top
NOREF#2247  -  []  60.48 63.12 0 top
NOREF#2248  -  []  41.14 100.28 0 top
NOREF#2249  -  []  49.17 96.52 270 top
NOREF#2250  -  []  33.78 28.7 90 top
NOREF#2251  -  []  146.13 128.09 90 top
NOREF#2252  -  []  128.91 12.4 0 top
NOREF#2253  -  []  54.81 29.07 0 top
NOREF#2254  -  []  122.68 26.29 0 top
NOREF#2255  -  []  71.55 27.7 270 top
NOREF#2256  -  []  121.16 17.44 90 top
NOREF#2257  -  []  158.39 110.74 90 top
NOREF#2258  -  []  57.91 75.68 90 top
NOREF#2259  -  []  120.52 32.18 90 top
NOREF#2260  -  []  142.98 121.23 90 top
NOREF#2261  -  []  19.76 34.15 90 top
NOREF#2262  -  []  18.31 193.29 0 top
NOREF#2263  -  []  74.19 50.83 90 top
NOREF#2264  -  []  88.76 37.72 0 top
NOREF#2265  -  []  54.31 150.04 0 top
NOREF#2266  -  []  54.31 147.75 0 top
NOREF#2267  -  []  65.68 188.59 0 top
NOREF#2268  -  []  126.47 32.17 270 top
NOREF#2269  -  []  37.13 27.44 270 top
NOREF#2270  -  []  141.05 18.72 0 top
NOREF#2271  -  []  19.76 33.74 0 top
NOREF#2272  -  []  126.48 49.92 0 top
NOREF#2273  -  []  26.15 39.42 0 top
NOREF#2274  -  []  93.8 101.65 90 top
NOREF#2275  -  []  17.98 29.07 90 top
NOREF#2276  -  []  74.42 87.48 0 top
NOREF#2277  -  []  47.93 28.69 90 top
NOREF#2278  -  []  42.44 108.23 90 top
NOREF#2279  -  []  133.54 83.95 0 top
NOREF#2280  -  []  76.53 108.15 90 top
NOREF#2281  -  []  57.53 17.44 90 top
NOREF#2282  -  []  139.67 89.36 0 top
NOREF#2283  -  []  87.4 92.2 270 top
NOREF#2284  -  []  101.73 109.07 270 top
NOREF#2285  -  []  148.03 193.5 0 top
NOREF#2286  -  []  136.78 183.13 90 top
NOREF#2287  -  []  140.49 133.35 0 top
NOREF#2288  -  []  84.56 93.55 0 top
NOREF#2289  -  []  28.83 36.82 90 top
NOREF#2290  -  []  50.55 25.78 90 top
NOREF#2291  -  []  120.51 29.72 0 top
NOREF#2292  -  []  55.83 109.87 0 top
NOREF#2293  -  []  65.23 188.16 0 top
NOREF#2294  -  []  12.52 117.17 0 top
NOREF#2295  -  []  63.88 18.41 90 top
NOREF#2296  -  []  40.39 92.08 270 top
NOREF#2297  -  []  85.29 108.79 0 top
NOREF#2298  -  []  119.53 135.64 0 top
NOREF#2299  -  []  55.5 25.26 90 top
NOREF#2300  -  []  91.43 27.3 0 top
NOREF#2301  -  []  151.66 91.19 0 top
NOREF#2302  -  []  150.91 180.09 0 top
NOREF#2303  -  []  54.43 151.05 270 top
NOREF#2304  -  []  146.63 112.67 0 top
NOREF#2305  -  []  64.1 91.07 90 top
NOREF#2306  -  []  84.91 100.63 270 top
NOREF#2307  -  []  133.46 44.63 0 top
NOREF#2308  -  []  85.01 91.97 0 top
NOREF#2309  -  []  116.93 38.75 270 top
NOREF#2310  -  []  101.24 97.13 0 top
NOREF#2311  -  []  114.73 153.24 90 top
NOREF#2312  -  []  59.13 91.64 270 top
NOREF#2313  -  []  74.92 23.8 0 top
NOREF#2314  -  []  96.52 17.44 90 top
NOREF#2315  -  []  88.76 34.09 0 top
NOREF#2316  -  []  151.97 20.4 90 top
NOREF#2317  -  []  130.25 36.61 90 top
NOREF#2318  -  []  40.96 25.63 90 top
NOREF#2319  -  []  82.6 27.75 270 top
NOREF#2320  -  []  71.36 31.62 0 top
NOREF#2321  -  []  134.11 184.14 90 top
NOREF#2322  -  []  103.14 93.93 0 top
NOREF#2323  -  []  94.55 102.08 0 top
NOREF#2324  -  []  42.28 34.47 0 top
NOREF#2325  -  []  75.46 100.71 0 top
NOREF#2326  -  []  133.4 130 0 top
NOREF#2327  -  []  56.31 173.56 90 top
NOREF#2328  -  []  156.67 102.41 0 top
NOREF#2329  -  []  153.19 87.88 90 top
NOREF#2330  -  []  103.3 61.26 270 top
NOREF#2331  -  []  71.6 31.79 270 top
NOREF#2332  -  []  46 139.57 0 top
NOREF#2333  -  []  70.33 83.36 270 top
NOREF#2334  -  []  43 67.61 0 top
NOREF#2335  -  []  135.81 131.28 270 top
NOREF#2336  -  []  19.76 31.99 0 top
NOREF#2337  -  []  138 18.72 0 top
NOREF#2338  -  []  126.57 53.23 0 top
NOREF#2339  -  []  61.44 52.74 270 top
NOREF#2340  -  []  66.37 0.56 90 top
NOREF#2341  -  []  142.49 175.01 90 top
NOREF#2342  -  []  134.86 48.51 0 top
NOREF#2343  -  []  131.19 141.99 270 top
NOREF#2344  -  []  102.64 93.97 90 top
NOREF#2345  -  []  123.44 170.43 90 top
NOREF#2346  -  []  68.28 181.94 90 top
NOREF#2347  -  []  151.66 92.33 0 top
NOREF#2348  -  []  24.31 28.59 90 top
NOREF#2349  -  []  149.66 71.63 0 top
NOREF#2350  -  []  136.22 65.07 0 top
NOREF#2351  -  []  58.55 109.56 270 top
NOREF#2352  -  []  129.55 42.24 90 top
NOREF#2353  -  []  136.83 142.43 90 top
NOREF#2354  -  []  34.79 28.19 0 top
NOREF#2355  -  []  44.86 45.36 0 top
NOREF#2356  -  []  67.89 150.32 0 top
NOREF#2357  -  []  82.14 104.85 90 top
NOREF#2358  -  []  59.27 91.68 270 top
NOREF#2359  -  []  30.56 31.89 0 top
NOREF#2360  -  []  92.93 100.68 0 top
NOREF#2361  -  []  91.03 100.95 0 top
NOREF#2362  -  []  26.29 38.85 90 top
NOREF#2363  -  []  138.23 120.42 90 top
NOREF#2364  -  []  9.55 108.86 0 top
NOREF#2365  -  []  120.62 72.9 0 top
NOREF#2366  -  []  71.32 31.76 270 top
NOREF#2367  -  []  62.09 34.47 0 top
NOREF#2368  -  []  95.4 99.34 90 top
NOREF#2369  -  []  47.32 28.33 0 top
NOREF#2370  -  []  63.7 27.47 0 top
NOREF#2371  -  []  9.73 66.75 0 top
NOREF#2372  -  []  135.81 44.56 90 top
NOREF#2373  -  []  54.36 168.66 90 top
NOREF#2374  -  []  114.87 25.65 90 top
NOREF#2375  -  []  66.19 51.33 90 top
NOREF#2376  -  []  117.81 154.38 270 top
NOREF#2377  -  []  28.69 32.13 0 top
NOREF#2378  -  []  51.73 109.55 270 top
NOREF#2379  -  []  62.18 51.38 90 top
NOREF#2380  -  []  25.4 67.09 0 top
NOREF#2381  -  []  135.64 135.08 0 top
NOREF#2382  -  []  89.28 32.42 0 top
NOREF#2383  -  []  6.96 109.8 0 top
NOREF#2384  -  []  127.58 88.57 270 top
NOREF#2385  -  []  20.93 116.76 270 top
NOREF#2386  -  []  66.37 177.47 0 top
NOREF#2387  -  []  34.04 33.52 90 top
NOREF#2388  -  []  67.13 84.12 270 top
NOREF#2389  -  []  42.44 110.64 0 top
NOREF#2390  -  []  75.72 52.58 0 top
NOREF#2391  -  []  51.61 101.04 0 top
NOREF#2392  -  []  108.03 60.04 90 top
NOREF#2393  -  []  152.01 97.93 90 top
NOREF#2394  -  []  76.89 102.03 270 top
NOREF#2395  -  []  139.34 43.97 90 top
NOREF#2396  -  []  73.14 29.21 0 top
NOREF#2397  -  []  135.36 89.36 90 top
NOREF#2398  -  [unnamed#2]  145.29 196.09 0 top
NOREF#2399  -  []  19.71 126.87 0 top
NOREF#2400  -  []  43.13 62.66 270 top
NOREF#2401  -  []  55.42 27.44 270 top
NOREF#2402  -  []  151.59 139.52 90 top
NOREF#2403  -  []  100.63 94.82 90 top
NOREF#2404  -  []  124.64 38.96 0 top
NOREF#2405  -  []  134.11 175.03 90 top
NOREF#2406  -  []  61.79 67.9 90 top
NOREF#2407  -  []  109.68 31.23 90 top
NOREF#2408  -  []  112.27 23.76 270 top
NOREF#2409  -  []  150.88 180.34 0 top
NOREF#2410  -  []  153.47 147.65 90 top
NOREF#2411  -  []  146.3 95.63 90 top
NOREF#2412  -  []  6.35 21.34 270 top
NOREF#2413  -  []  55.36 23.8 270 top
NOREF#2414  -  []  28.96 38.89 90 top
NOREF#2415  -  []  123.39 171.75 270 top
NOREF#2416  -  []  127.19 55.3 0 top
NOREF#2417  -  []  61.79 60.41 90 top
NOREF#2418  -  []  52.32 33.52 90 top
NOREF#2419  -  []  140.02 89.66 0 top
NOREF#2420  -  []  95.96 25.69 90 top
NOREF#2421  -  []  98.67 34.47 0 top
NOREF#2422  -  []  150.57 177.5 0 top
NOREF#2423  -  []  153.5 57.37 0 top
NOREF#2424  -  []  141.05 17.09 90 top
NOREF#2425  -  []  130.71 174.24 0 top
NOREF#2426  -  []  101.8 33.6 0 top
NOREF#2427  -  []  139.42 101.04 0 top
NOREF#2428  -  []  141.35 120.7 0 top
NOREF#2429  -  []  46.89 76.07 270 top
NOREF#2430  -  []  83.95 32.18 90 top
NOREF#2431  -  []  36.27 40.94 0 top
NOREF#2432  -  []  84.12 58.42 270 top
NOREF#2433  -  []  123.05 41.59 90 top
NOREF#2434  -  []  66.92 26.92 0 top
NOREF#2435  -  []  52.7 58.29 270 top
NOREF#2436  -  []  54.55 197.56 90 top
NOREF#2437  -  []  93.34 23.76 270 top
NOREF#2438  -  []  54.31 148.03 0 top
NOREF#2439  -  []  48.41 140.72 0 top
NOREF#2440  -  []  70.33 143.46 0 top
NOREF#2441  -  []  76.02 18.72 0 top
NOREF#2442  -  []  17.73 108.92 90 top
NOREF#2443  -  []  29.55 197.56 90 top
NOREF#2444  -  []  18.15 39.55 270 top
NOREF#2445  -  []  70.47 33.48 90 top
NOREF#2446  -  []  132.66 56.34 0 top
NOREF#2447  -  []  137.85 43.26 0 top
NOREF#2448  -  []  33.9 34.09 0 top
NOREF#2449  -  []  55.14 78.16 0 top
NOREF#2450  -  []  20.43 39.19 0 top
NOREF#2451  -  []  137.79 184.11 270 top
NOREF#2452  -  []  41.86 25.67 90 top
NOREF#2453  -  []  147.12 120.47 0 top
NOREF#2454  -  []  42.71 102.77 0 top
NOREF#2455  -  []  73.69 84.1 270 top
NOREF#2456  -  []  87.66 92.16 270 top
NOREF#2457  -  []  15.52 108.74 0 top
NOREF#2458  -  []  124.64 38.96 90 top
NOREF#2459  -  []  123.52 78.28 0 top
NOREF#2460  -  []  150.99 99.86 0 top
NOREF#2461  -  []  53.29 147.5 0 top
NOREF#2462  -  []  103.12 63.75 90 top
NOREF#2463  -  []  43.69 36.06 90 top
NOREF#2464  -  []  16.09 170.56 0 top
NOREF#2465  -  []  124.45 42.55 0 top
NOREF#2466  -  []  135.59 35.89 90 top
NOREF#2467  -  []  63.74 26.85 0 top
NOREF#2468  -  []  107.57 32.42 0 top
NOREF#2469  -  []  61.47 33.9 90 top
NOREF#2470  -  []  49.57 26.04 0 top
NOREF#2471  -  []  54.85 29.21 0 top
NOREF#2472  -  []  53.21 72.14 90 top
NOREF#2473  -  []  138.1 184.45 270 top
NOREF#2474  -  []  61.79 61.55 90 top
NOREF#2475  -  []  43.13 63.68 270 top
NOREF#2476  -  []  140.59 47.24 90 top
NOREF#2477  -  []  61.2 36.02 90 top
NOREF#2478  -  []  139.37 29.07 90 top
NOREF#2479  -  []  116.13 132.66 0 top
NOREF#2480  -  []  91.94 23.8 0 top
NOREF#2481  -  []  136.73 75.01 90 top
NOREF#2482  -  []  52.2 58.55 270 top
NOREF#2483  -  []  110.03 63.11 90 top
NOREF#2484  -  []  92 26.68 270 top
NOREF#2485  -  []  149.42 12.67 0 top
NOREF#2486  -  []  18.8 180.09 0 top
NOREF#2487  -  []  51.88 112.08 270 top
NOREF#2488  -  []  112.98 36.23 90 top
NOREF#2489  -  []  42.61 25.63 0 top
NOREF#2490  -  []  135.69 88.39 0 top
NOREF#2491  -  []  108.71 12.5 0 top
NOREF#2492  -  []  152.91 140.96 90 top
NOREF#2493  -  []  60.78 62.56 0 top
NOREF#2494  -  []  70.98 29.84 0 top
NOREF#2495  -  []  89.92 36.59 270 top
NOREF#2496  -  []  151.38 121.79 270 top
NOREF#2497  -  []  53.07 26.29 0 top
NOREF#2498  -  []  119.08 133.05 0 top
NOREF#2499  -  []  57.86 37.21 270 top
NOREF#2500  -  []  57.29 91.53 0 top
NOREF#2501  -  []  75.46 106.68 0 top
NOREF#2502  -  []  70.98 28.83 0 top
NOREF#2503  -  []  42.97 94.82 270 top
NOREF#2504  -  []  123.42 70.43 0 top
NOREF#2505  -  []  17.48 107.26 90 top
NOREF#2506  -  []  75.77 52.27 270 top
NOREF#2507  -  []  61.79 64.6 90 top
NOREF#2508  -  []  127.33 37.77 0 top
NOREF#2509  -  []  62.48 113.06 90 top
NOREF#2510  -  []  131.85 85.6 90 top
NOREF#2511  -  []  67.51 25.73 0 top
NOREF#2512  -  []  116.71 17.44 90 top
NOREF#2513  -  []  140.72 177.83 270 top
NOREF#2514  -  []  118.24 174.12 0 top
NOREF#2515  -  []  51.45 109.55 0 top
NOREF#2516  -  []  152.35 120.35 0 top
NOREF#2517  -  []  65.65 33.78 0 top
NOREF#2518  -  []  65.65 29.72 0 top
NOREF#2519  -  []  142.82 126.03 90 top
NOREF#2520  -  []  125.72 37.01 0 top
NOREF#2521  -  []  17.22 53.54 0 top
NOREF#2522  -  []  125.34 34.47 0 top
NOREF#2523  -  []  48.59 27.06 0 top
NOREF#2524  -  []  100.25 24.54 90 top
NOREF#2525  -  []  151.21 89.61 0 top
NOREF#2526  -  []  152.78 136.18 90 top
NOREF#2527  -  []  102.87 63.72 270 top
NOREF#2528  -  []  91.07 101.09 0 top
NOREF#2529  -  []  52.18 34.09 0 top
NOREF#2530  -  []  55.68 58.6 270 top
NOREF#2531  -  []  139.93 100.38 0 top
NOREF#2532  -  []  70.85 36.63 270 top
NOREF#2533  -  []  75.55 23.8 270 top
NOREF#2534  -  []  62.23 67.44 270 top
NOREF#2535  -  []  36.18 193.15 270 top
NOREF#2536  -  []  134.37 148.21 0 top
NOREF#2537  -  []  100.89 26.99 270 top
NOREF#2538  -  []  6.93 108.92 0 top
NOREF#2539  -  []  129.67 136.68 90 top
NOREF#2540  -  []  56.43 97.98 90 top
NOREF#2541  -  []  135.25 136.27 0 top
NOREF#2542  -  []  107.9 26.15 0 top
NOREF#2543  -  []  135.69 87 0 top
NOREF#2544  -  []  134.25 53.04 90 top
NOREF#2545  -  []  79.63 36.59 270 top
NOREF#2546  -  []  85.91 54.61 90 top
NOREF#2547  -  []  41 90.27 0 top
NOREF#2548  -  []  137.25 121.56 0 top
NOREF#2549  -  []  144.87 2.26 0 top
NOREF#2550  -  []  100.58 139.42 270 top
NOREF#2551  -  []  137.04 76.08 90 top
NOREF#2552  -  []  82.45 53.98 270 top
NOREF#2553  -  []  124.08 45.92 0 top
NOREF#2554  -  []  20.71 28.18 90 top
NOREF#2555  -  []  124.92 54.43 0 top
NOREF#2556  -  []  115.49 84.96 0 top
NOREF#2557  -  []  109.21 155.28 0 top
NOREF#2558  -  []  128.78 42.28 90 top
NOREF#2559  -  []  18.02 34.54 0 top
NOREF#2560  -  []  140.11 107.24 90 top
NOREF#2561  -  []  74.14 194.39 90 top
NOREF#2562  -  []  88.72 37.86 0 top
NOREF#2563  -  []  134.37 151.51 0 top
NOREF#2564  -  []  93.04 190.7 0 top
NOREF#2565  -  []  51 151.18 0 top
NOREF#2566  -  []  20.4 77.77 270 top
NOREF#2567  -  []  102.87 139.42 270 top
NOREF#2568  -  []  75.01 103.17 0 top
NOREF#2569  -  []  31.19 192.1 90 top
NOREF#2570  -  []  83.52 56.79 0 top
NOREF#2571  -  []  150.88 179.83 90 top
NOREF#2572  -  []  135.23 87.43 0 top
NOREF#2573  -  []  53.64 27.42 90 top
NOREF#2574  -  []  145.95 147.6 90 top
NOREF#2575  -  []  107.57 36.59 270 top
NOREF#2576  -  []  73.51 110.57 0 top
NOREF#2577  -  []  55.36 25.22 90 top
NOREF#2578  -  []  17.02 109.26 90 top
NOREF#2579  -  []  74.28 23.8 0 top
NOREF#2580  -  []  34.79 31.62 0 top
NOREF#2581  -  []  51.84 76.07 270 top
NOREF#2582  -  []  134.7 182.83 0 top
NOREF#2583  -  []  5.13 118.64 0 top
NOREF#2584  -  []  70.98 28.19 0 top
NOREF#2585  -  []  151.59 150.32 0 top
NOREF#2586  -  []  81.03 18.41 270 top
NOREF#2587  -  []  37.85 23.76 270 top
NOREF#2588  -  []  43.13 62.05 0 top
NOREF#2589  -  []  131.56 44.63 0 top
NOREF#2590  -  []  119.2 152.48 0 top
NOREF#2591  -  []  27.18 37.35 270 top
NOREF#2592  -  []  25.22 36.87 90 top
NOREF#2593  -  []  41.12 79.45 0 top
NOREF#2594  -  []  44.87 2.26 0 top
NOREF#2595  -  []  28.88 127.3 270 top
NOREF#2596  -  []  145.44 105.66 0 top
NOREF#2597  -  []  39.9 67.18 0 top
NOREF#2598  -  []  136.78 79.24 90 top
NOREF#2599  -  []  63.07 109.87 0 top
NOREF#2600  -  []  115.72 43.28 0 top
NOREF#2601  -  []  58.53 98.26 270 top
NOREF#2602  -  []  137.24 105.23 0 top
NOREF#2603  -  []  140.59 78.23 90 top
NOREF#2604  -  []  7.75 72.03 90 top
NOREF#2605  -  []  54.55 104.53 270 top
NOREF#2606  -  []  50.79 104.27 90 top
NOREF#2607  -  []  84.51 33.29 270 top
NOREF#2608  -  []  53.92 51.51 0 top
NOREF#2609  -  []  43.43 62.61 0 top
NOREF#2610  -  []  64.14 75.53 270 top
NOREF#2611  -  []  48.46 151.05 0 top
NOREF#2612  -  []  73.69 83.92 270 top
NOREF#2613  -  []  106.78 154.76 0 top
NOREF#2614  -  []  140.59 44.83 0 top
NOREF#2615  -  []  66.22 32.37 90 top
NOREF#2616  -  []  66.84 100.29 270 top
NOREF#2617  -  []  127.33 74.22 0 top
NOREF#2618  -  []  105.16 138.46 90 top
NOREF#2619  -  []  19.56 81.92 270 top
NOREF#2620  -  []  53.29 77.84 90 top
NOREF#2621  -  []  134.06 150.95 90 top
NOREF#2622  -  []  17.98 35.04 90 top
NOREF#2623  -  []  133.86 97.66 0 top
NOREF#2624  -  []  121.41 18.41 90 top
NOREF#2625  -  []  97.03 58.04 270 top
NOREF#2626  -  []  39.83 36.23 90 top
NOREF#2627  -  []  134.06 148.67 0 top
NOREF#2628  -  []  95.86 108.03 90 top
NOREF#2629  -  []  39.9 66.04 0 top
NOREF#2630  -  []  146.87 0.16 90 top
NOREF#2631  -  []  49.66 57.23 90 top
NOREF#2632  -  []  152.53 136.14 90 top
NOREF#2633  -  []  150.29 134.54 270 top
NOREF#2634  -  []  134.26 149.76 90 top
NOREF#2635  -  []  89.31 107.19 0 top
NOREF#2636  -  []  30.94 32.35 0 top
NOREF#2637  -  []  129.18 139.32 0 top
NOREF#2638  -  []  74.19 50.83 0 top
NOREF#2639  -  []  136.53 78.27 90 top
NOREF#2640  -  []  74.92 23.8 270 top
NOREF#2641  -  []  16.71 108.92 0 top
NOREF#2642  -  []  38.96 101.3 0 top
NOREF#2643  -  []  121.74 27.06 0 top
NOREF#2644  -  []  56.34 76 0 top
NOREF#2645  -  []  118.11 17.44 90 top
NOREF#2646  -  []  124.79 137.97 0 top
NOREF#2647  -  []  150.6 149.83 0 top
NOREF#2648  -  []  148.51 129.49 0 top
NOREF#2649  -  []  132.05 72.09 0 top
NOREF#2650  -  []  44.88 68.76 270 top
NOREF#2651  -  []  125.98 154.28 270 top
NOREF#2652  -  []  120.53 31.62 90 top
NOREF#2653  -  []  109.6 155.32 90 top
NOREF#2654  -  []  135.05 131.62 270 top
NOREF#2655  -  []  42.55 125.32 270 top
NOREF#2656  -  []  54.18 49.81 270 top
NOREF#2657  -  []  125.86 32.8 0 top
NOREF#2658  -  []  132.99 88.14 90 top
NOREF#2659  -  []  140.03 134.06 0 top
NOREF#2660  -  []  10.01 79.75 0 top
NOREF#2661  -  []  21.21 39.23 90 top
NOREF#2662  -  []  32.8 28.96 0 top
NOREF#2663  -  []  125.08 58.13 0 top
NOREF#2664  -  []  98.95 34.47 270 top
NOREF#2665  -  []  115.42 87.71 90 top
NOREF#2666  -  []  152.48 137.46 0 top
NOREF#2667  -  []  49.56 73.46 0 top
NOREF#2668  -  []  127.04 139.32 0 top
NOREF#2669  -  []  144.73 92.02 90 top
NOREF#2670  -  []  157.09 184.15 0 top
NOREF#2671  -  []  134.06 147.5 0 top
NOREF#2672  -  []  39.45 62.66 270 top
NOREF#2673  -  []  99.44 35.97 90 top
NOREF#2674  -  []  83.52 33.6 0 top
NOREF#2675  -  []  18.02 33.4 0 top
NOREF#2676  -  []  150.88 192.28 0 top
NOREF#2677  -  []  91.39 29.07 0 top
NOREF#2678  -  []  151.82 149.12 90 top
NOREF#2679  -  []  138.99 176.42 90 top
NOREF#2680  -  []  116.41 18.72 0 top
NOREF#2681  -  []  83.9 32.65 0 top
NOREF#2682  -  []  80.09 40.54 270 top
NOREF#2683  -  []  136.86 27.09 0 top
NOREF#2684  -  []  21.34 72.75 270 top
NOREF#2685  -  []  72.47 53.51 270 top
NOREF#2686  -  []  67.56 84.07 90 top
NOREF#2687  -  []  100.32 26.85 0 top
NOREF#2688  -  []  31.83 30.34 0 top
NOREF#2689  -  []  139.61 179.07 0 top
NOREF#2690  -  []  109.68 26.4 0 top
NOREF#2691  -  []  126.25 33.86 90 top
NOREF#2692  -  []  83.5 108.51 0 top
NOREF#2693  -  []  34.75 28.97 270 top
NOREF#2694  -  []  135.69 90.81 0 top
NOREF#2695  -  []  121.67 76.86 90 top
NOREF#2696  -  []  151.66 90.04 0 top
NOREF#2697  -  []  144.48 72.95 270 top
NOREF#2698  -  []  87.22 93.04 0 top
NOREF#2699  -  []  132.07 54.81 90 top
NOREF#2700  -  []  146.58 128.52 0 top
NOREF#2701  -  []  107.9 31.48 0 top
NOREF#2702  -  []  150.91 191.39 0 top
NOREF#2703  -  []  132.11 85.64 90 top
NOREF#2704  -  []  137.24 46.47 0 top
NOREF#2705  -  []  138.63 122.05 0 top
NOREF#2706  -  []  101.68 35.1 0 top
NOREF#2707  -  []  34.91 36.63 270 top
NOREF#2708  -  []  139.09 139.47 90 top
NOREF#2709  -  []  140.67 26.11 0 top
NOREF#2710  -  []  120.22 134.92 0 top
NOREF#2711  -  []  11.58 110.74 0 top
NOREF#2712  -  []  83.9 28.33 0 top
NOREF#2713  -  []  68.33 182.25 90 top
NOREF#2714  -  []  150.22 114 0 top
NOREF#2715  -  []  55.7 77.84 90 top
NOREF#2716  -  []  132.66 174.7 0 top
NOREF#2717  -  []  144.86 182.3 0 top
NOREF#2718  -  []  84.87 2.26 0 top
NOREF#2719  -  []  76.71 26.23 270 top
NOREF#2720  -  []  139.47 78.23 90 top
NOREF#2721  -  []  98.64 37.95 0 top
NOREF#2722  -  []  120.47 29.86 270 top
NOREF#2723  -  []  51.64 173.61 0 top
NOREF#2724  -  []  130.42 24.18 270 top
NOREF#2725  -  []  89.34 106.93 0 top
NOREF#2726  -  []  83.93 33.15 0 top
NOREF#2727  -  []  63.88 17.4 90 top
NOREF#2728  -  []  24.77 178.51 0 top
NOREF#2729  -  []  63.88 34.48 270 top
NOREF#2730  -  []  125.86 36.97 270 top
NOREF#2731  -  []  139.93 99.77 90 top
NOREF#2732  -  []  149.17 70.56 270 top
NOREF#2733  -  []  140.24 177.16 90 top
NOREF#2734  -  []  50.44 51.84 0 top
NOREF#2735  -  []  124 26.34 270 top
NOREF#2736  -  []  128.52 173.99 90 top
NOREF#2737  -  []  143.05 73.79 0 top
NOREF#2738  -  []  136.65 133.15 90 top
NOREF#2739  -  []  125.09 76.86 90 top
NOREF#2740  -  []  109.91 151.21 90 top
NOREF#2741  -  []  1.27 31.5 270 top
NOREF#2742  -  []  66.33 97.75 0 top
NOREF#2743  -  []  133.48 42.28 90 top
NOREF#2744  -  []  120.62 75.74 270 top
NOREF#2745  -  []  83.99 26.04 0 top
NOREF#2746  -  []  87 51.08 90 top
NOREF#2747  -  []  63.12 109.56 90 top
NOREF#2748  -  []  110.29 27.44 270 top
NOREF#2749  -  []  73.18 54.89 0 top
NOREF#2750  -  []  137.81 111.93 90 top
NOREF#2751  -  []  134.99 36.4 0 top
NOREF#2752  -  []  59.25 25.63 90 top
NOREF#2753  -  []  86.06 93.54 270 top
NOREF#2754  -  []  66.88 95.07 0 top
NOREF#2755  -  []  59.66 72.11 90 top
NOREF#2756  -  []  132.36 73.37 270 top
NOREF#2757  -  []  122.83 159.13 0 top
NOREF#2758  -  []  61.04 51.38 0 top
NOREF#2759  -  []  14.76 20.47 90 top
NOREF#2760  -  []  138.3 83.95 90 top
NOREF#2761  -  []  19.63 108.79 0 top
NOREF#2762  -  []  108.62 153.16 0 top
NOREF#2763  -  []  65.13 66.34 0 top
NOREF#2764  -  []  134.37 148.72 90 top
NOREF#2765  -  []  123.65 44.25 0 top
NOREF#2766  -  []  43.38 123.9 0 top
NOREF#2767  -  []  142.47 67.74 0 top
NOREF#2768  -  []  53.07 31.62 0 top
NOREF#2769  -  []  44.83 34.48 270 top
NOREF#2770  -  []  139.47 79.24 90 top
NOREF#2771  -  []  146.58 122.1 270 top
NOREF#2772  -  []  152.68 87.88 90 top
NOREF#2773  -  []  110.22 25.22 0 top
NOREF#2774  -  []  93.5 191.13 0 top
NOREF#2775  -  []  18.05 36.4 90 top
NOREF#2776  -  []  130.25 173.81 0 top
NOREF#2777  -  []  130.1 133.68 90 top
NOREF#2778  -  []  120.75 104.7 270 top
NOREF#2779  -  []  19.8 33.6 0 top
NOREF#2780  -  []  60.82 61.8 0 top
NOREF#2781  -  []  54.76 149.61 0 top
NOREF#2782  -  []  54.48 75.69 270 top
NOREF#2783  -  []  85.72 108.05 270 top
NOREF#2784  -  []  130.42 42.24 0 top
NOREF#2785  -  []  133.27 174.7 90 top
NOREF#2786  -  []  60.78 67.89 0 top
NOREF#2787  -  []  126.44 157.15 270 top
NOREF#2788  -  []  47.17 58.52 90 top
NOREF#2789  -  []  18.57 22.1 0 top
NOREF#2790  -  []  53.21 57.28 90 top
NOREF#2791  -  []  140.89 179.37 270 top
NOREF#2792  -  []  27.32 37.39 270 top
NOREF#2793  -  []  37.21 23.76 270 top
NOREF#2794  -  []  62.1 67.84 90 top
NOREF#2795  -  []  44.86 45.36 90 top
NOREF#2796  -  []  127.23 56.95 270 top
NOREF#2797  -  []  146.86 103.81 270 top
NOREF#2798  -  []  19.13 40.31 0 top
NOREF#2799  -  []  128.75 65.04 0 top
NOREF#2800  -  []  25.07 178.56 90 top
NOREF#2801  -  []  109.93 62.63 0 top
NOREF#2802  -  []  2.24 53.54 0 top
NOREF#2803  -  []  92.93 99.68 90 top
NOREF#2804  -  []  152.1 115.14 90 top
NOREF#2805  -  []  110.35 36.27 0 top
NOREF#2806  -  []  119.08 87.71 90 top
NOREF#2807  -  []  72.9 36.93 270 top
NOREF#2808  -  []  94.69 18.72 0 top
NOREF#2809  -  []  142.57 62.05 90 top
NOREF#2810  -  []  117.35 153.9 270 top
NOREF#2811  -  []  94.97 100.76 0 top
NOREF#2812  -  []  66.22 28.69 90 top
NOREF#2813  -  []  73.77 36.27 0 top
NOREF#2814  -  []  132.69 88.09 90 top
NOREF#2815  -  []  134.87 158.6 270 top
NOREF#2816  -  []  124.28 66.37 0 top
NOREF#2817  -  []  124.21 181.73 90 top
NOREF#2818  -  []  91.39 31.23 90 top
NOREF#2819  -  []  51.94 46.51 90 top
NOREF#2820  -  []  61.04 51.38 90 top
NOREF#2821  -  []  58.24 167.18 0 top
NOREF#2822  -  []  54.31 168.35 0 top
NOREF#2823  -  []  140.03 132.92 90 top
NOREF#2824  -  []  55.12 113.07 270 top
NOREF#2825  -  []  128.52 174.5 0 top
NOREF#2826  -  []  54.99 52.83 270 top
NOREF#2827  -  []  65.1 35.1 0 top
NOREF#2828  -  []  33.54 33.48 90 top
NOREF#2829  -  []  67.03 102.95 0 top
NOREF#2830  -  []  145.44 190.75 0 top
NOREF#2831  -  []  129.95 37.9 0 top
NOREF#2832  -  []  54.74 150.5 90 top
NOREF#2833  -  []  118.88 34.52 270 top
NOREF#2834  -  []  140.63 53.59 0 top
NOREF#2835  -  []  30.59 31.75 0 top
NOREF#2836  -  []  69.65 84.05 0 top
NOREF#2837  -  []  126.19 32.78 270 top
NOREF#2838  -  []  60.64 101.51 0 top
NOREF#2839  -  []  43 65.48 0 top
NOREF#2840  -  []  139.55 106.93 90 top
NOREF#2841  -  []  17.91 67.09 0 top
NOREF#2842  -  []  133.3 156.01 270 top
NOREF#2843  -  []  38.51 93.22 0 top
NOREF#2844  -  []  48.77 150.5 0 top
NOREF#2845  -  []  127.56 41.03 270 top
NOREF#2846  -  []  64.03 64.8 90 top
NOREF#2847  -  []  83.49 100.2 0 top
NOREF#2848  -  []  67.13 82.5 0 top
NOREF#2849  -  []  130.63 55.42 0 top
NOREF#2850  -  []  145.24 148.82 0 top
NOREF#2851  -  []  1.14 178.69 0 top
NOREF#2852  -  []  34.79 26.29 0 top
NOREF#2853  -  []  145.69 99.19 90 top
NOREF#2854  -  []  65.1 67.49 270 top
NOREF#2855  -  []  47.32 33.29 0 top
NOREF#2856  -  []  102.16 104.7 270 top
NOREF#2857  -  []  150.57 176.35 0 top
NOREF#2858  -  []  76.1 37.52 0 top
NOREF#2859  -  []  53.92 76 0 top
NOREF#2860  -  []  118.97 108.92 0 top
NOREF#2861  -  []  19.13 106.12 90 top
NOREF#2862  -  []  133.4 84.3 0 top
NOREF#2863  -  []  151.88 192.28 90 top
NOREF#2864  -  []  18.75 108.92 90 top
NOREF#2865  -  []  1.27 179.83 0 top
NOREF#2866  -  []  156.54 183.69 0 top
NOREF#2867  -  []  106.37 0.56 90 top
NOREF#2868  -  []  140.24 177.16 0 top
NOREF#2869  -  []  55.5 55.84 270 top
NOREF#2870  -  []  123.05 41.59 0 top
NOREF#2871  -  []  102.79 28.69 90 top
NOREF#2872  -  []  7.62 5.84 90 top
NOREF#2873  -  []  141.25 148.16 90 top
NOREF#2874  -  []  137.27 45.97 0 top
NOREF#2875  -  []  65.61 91.11 90 top
NOREF#2876  -  []  19.76 33.46 90 top
NOREF#2877  -  []  139.81 179.96 0 top
NOREF#2878  -  []  20.07 109.25 90 top
NOREF#2879  -  []  79.73 108.03 0 top
NOREF#2880  -  []  70.76 82.91 270 top
NOREF#2881  -  []  154.97 114.31 90 top
NOREF#2882  -  []  136.78 78.23 90 top
NOREF#2883  -  []  131.32 176.91 90 top
NOREF#2884  -  []  125.34 34.47 270 top
NOREF#2885  -  []  133.45 131.32 270 top
NOREF#2886  -  []  71.86 82.68 0 top
NOREF#2887  -  []  134.95 136.32 270 top
NOREF#2888  -  []  124.28 65.23 90 top
NOREF#2889  -  []  143.43 120.27 90 top
NOREF#2890  -  []  154.98 115.32 90 top
NOREF#2891  -  []  137.24 101.8 0 top
NOREF#2892  -  []  47.37 25.78 0 top
NOREF#2893  -  []  107.9 30.62 270 top
NOREF#2894  -  []  87.66 93.19 270 top
NOREF#2895  -  []  103.58 138 90 top
NOREF#2896  -  []  100.58 35.97 90 top
NOREF#2897  -  []  109.68 30.47 90 top
NOREF#2898  -  []  128.67 72.39 90 top
NOREF#2899  -  []  47.36 33.15 0 top
NOREF#2900  -  []  73.81 108.61 90 top
NOREF#2901  -  []  61.33 34.47 0 top
NOREF#2902  -  []  65.68 188.59 0 top
NOREF#2903  -  []  70.99 32.42 0 top
NOREF#2904  -  []  120.62 75.74 0 top
NOREF#2905  -  []  58.7 171.32 0 top
NOREF#2906  -  []  49.35 105.99 0 top
NOREF#2907  -  []  7.19 78.79 0 top
NOREF#2908  -  []  30.56 31.25 0 top
NOREF#2909  -  []  85.5 103.25 0 top
NOREF#2910  -  []  131.27 178.23 270 top
NOREF#2911  -  []  36.75 35.51 90 top
NOREF#2912  -  []  57.78 18.41 90 top
NOREF#2913  -  []  58.08 103.59 270 top
NOREF#2914  -  []  135.51 130 0 top
NOREF#2915  -  []  121.92 181.7 270 top
NOREF#2916  -  []  150.57 191.69 270 top
NOREF#2917  -  []  17.98 33.26 90 top
NOREF#2918  -  []  127.7 72.64 0 top
NOREF#2919  -  []  57.28 109.6 270 top
NOREF#2920  -  []  84.51 33.92 270 top
NOREF#2921  -  []  135.41 104.52 0 top
NOREF#2922  -  []  137.81 111.93 90 top
NOREF#2923  -  []  131.83 177.93 270 top
NOREF#2924  -  []  13.61 67.09 90 top
NOREF#2925  -  []  59.13 102.08 270 top
NOREF#2926  -  []  47.36 28.83 0 top
NOREF#2927  -  []  89.65 31.62 0 top
NOREF#2928  -  []  68.33 12.5 0 top
NOREF#2929  -  []  124.12 47.19 0 top
NOREF#2930  -  []  111.53 62.61 90 top
NOREF#2931  -  []  119.61 102.82 90 top
NOREF#2932  -  []  112.32 153.59 270 top
NOREF#2933  -  []  102.16 107.11 270 top
NOREF#2934  -  []  49.35 108.38 270 top
NOREF#2935  -  []  88.85 109.27 270 top
NOREF#2936  -  []  88.82 92.18 270 top
NOREF#2937  -  []  142.49 178.03 270 top
NOREF#2938  -  []  39.99 25.63 0 top
NOREF#2939  -  []  94.21 102.39 0 top
NOREF#2940  -  []  39.83 123.37 0 top
NOREF#2941  -  []  60 113.06 90 top
NOREF#2942  -  []  47.62 30.65 90 top
NOREF#2943  -  []  146.13 173.66 270 top
NOREF#2944  -  []  142.98 120.09 90 top
NOREF#2945  -  []  126.44 54.89 90 top
NOREF#2946  -  []  111.66 159.89 0 top
NOREF#2947  -  []  134.11 183.13 90 top
NOREF#2948  -  []  45.59 34.48 270 top
NOREF#2949  -  []  120.62 70.28 0 top
NOREF#2950  -  []  47.37 30.61 90 top
NOREF#2951  -  []  153.16 139.99 90 top
NOREF#2952  -  []  80.66 33.86 90 top
NOREF#2953  -  []  91.94 23.8 270 top
NOREF#2954  -  []  66.37 97.61 0 top
NOREF#2955  -  []  136.22 63.45 90 top
NOREF#2956  -  []  126.44 159.56 0 top
NOREF#2957  -  []  146.02 121.79 270 top
NOREF#2958  -  []  139.83 127.61 270 top
NOREF#2959  -  []  53.04 28.05 0 top
NOREF#2960  -  []  20.38 26.54 0 top
NOREF#2961  -  []  55.37 109.56 90 top
NOREF#2962  -  []  86.69 51.42 90 top
NOREF#2963  -  []  89.65 28.19 0 top
NOREF#2964  -  []  58.09 58.6 270 top
NOREF#2965  -  []  67.86 26.04 0 top
NOREF#2966  -  []  139.78 40.21 90 top
NOREF#2967  -  []  137.85 89.66 0 top
NOREF#2968  -  []  43 65.2 270 top
NOREF#2969  -  []  96.9 91.68 90 top
NOREF#2970  -  []  47.36 29.72 0 top
NOREF#2971  -  []  136.83 126.44 90 top
NOREF#2972  -  []  87.35 92.51 0 top
NOREF#2973  -  []  134.95 87.96 90 top
NOREF#2974  -  []  84.07 18.41 270 top
NOREF#2975  -  []  141.99 120.73 90 top
NOREF#2976  -  []  140.28 45.8 0 top
NOREF#2977  -  []  126.19 32.5 0 top
NOREF#2978  -  []  88.85 108.41 0 top
NOREF#2979  -  []  133.68 174.57 90 top
NOREF#2980  -  []  151.82 12.87 0 top
NOREF#2981  -  []  126.54 132.26 270 top
NOREF#2982  -  []  146.14 109.21 270 top
NOREF#2983  -  []  156.7 55.37 90 top
NOREF#2984  -  []  52.1 145.06 0 top
NOREF#2985  -  []  126.19 28.71 270 top
NOREF#2986  -  []  140.16 71.58 0 top
NOREF#2987  -  []  81.02 18.41 90 top
NOREF#2988  -  []  34.42 31.51 0 top
NOREF#2989  -  []  142.62 70.61 270 top
NOREF#2990  -  []  55.75 173.86 90 top
NOREF#2991  -  []  134.76 34.85 270 top
NOREF#2992  -  []  70.31 38.09 90 top
NOREF#2993  -  []  138.89 173.15 0 top
NOREF#2994  -  []  53.54 113.37 0 top
NOREF#2995  -  []  62.42 101.51 90 top
NOREF#2996  -  []  39.9 61.09 0 top
NOREF#2997  -  []  147.29 65.99 0 top
NOREF#2998  -  []  94.44 36.2 90 top
NOREF#2999  -  []  41.77 103.45 90 top
NOREF#3000  -  []  63.82 91.68 0 top
NOREF#3001  -  []  128.22 173.94 0 top
NOREF#3002  -  []  82.5 51.38 90 top
NOREF#3003  -  []  131.09 126.87 0 top
NOREF#3004  -  []  31.83 30.34 90 top
NOREF#3005  -  []  83.95 31.62 270 top
NOREF#3006  -  []  37.83 104.72 0 top
NOREF#3007  -  []  129.24 135.56 0 top
NOREF#3008  -  []  48.46 73.08 270 top
NOREF#3009  -  []  108.2 36.59 270 top
NOREF#3010  -  []  53.98 103.96 270 top
NOREF#3011  -  []  55.63 36.84 270 top
NOREF#3012  -  []  90.75 37.39 0 top
NOREF#3013  -  []  36.53 30.47 90 top
NOREF#3014  -  []  48.41 138.43 0 top
NOREF#3015  -  []  63.73 78.16 0 top
NOREF#3016  -  []  52.88 150.32 90 top
NOREF#3017  -  []  66.93 158.39 90 top
NOREF#3018  -  []  83.64 51.38 90 top
NOREF#3019  -  []  34.75 28.69 0 top
NOREF#3020  -  []  55.85 166.7 0 top
NOREF#3021  -  []  91.43 30.61 0 top
NOREF#3022  -  []  58.74 113.03 270 top
NOREF#3023  -  []  135.94 69.93 90 top
NOREF#3024  -  []  125.4 72.31 270 top
NOREF#3025  -  []  118.49 153.89 270 top
NOREF#3026  -  []  52.96 33.52 90 top
NOREF#3027  -  []  115.44 18.41 90 top
NOREF#3028  -  []  151.22 102.19 270 top
NOREF#3029  -  []  132.92 134.04 0 top
NOREF#3030  -  []  148.01 134.54 270 top
NOREF#3031  -  []  37.07 23.8 270 top
NOREF#3032  -  []  53.29 145.87 90 top
NOREF#3033  -  []  82.19 105.16 90 top
NOREF#3034  -  []  73.1 31.51 0 top
NOREF#3035  -  []  108.42 55.06 0 top
NOREF#3036  -  []  126.8 27.8 90 top
NOREF#3037  -  []  100.72 94.23 0 top
NOREF#3038  -  []  55.07 73.46 0 top
NOREF#3039  -  []  54.1 113.06 90 top
NOREF#3040  -  []  150.88 176.91 0 top
NOREF#3041  -  []  136.14 133.65 90 top
NOREF#3042  -  []  74.52 110.03 0 top
NOREF#3043  -  []  72.11 82.09 0 top
NOREF#3044  -  []  120.52 171.45 270 top
NOREF#3045  -  []  150.57 192.84 0 top
NOREF#3046  -  []  153.09 90.47 270 top
NOREF#3047  -  []  15.44 108 0 top
NOREF#3048  -  []  140.23 99.82 0 top
NOREF#3049  -  []  131.9 156.67 0 top
NOREF#3050  -  []  133.34 42.85 0 top
NOREF#3051  -  []  14.38 108.74 90 top
NOREF#3052  -  []  127.23 56.95 0 top
NOREF#3053  -  []  45.67 138.13 90 top
NOREF#3054  -  []  36.65 178.1 0 top
NOREF#3055  -  []  138.76 29.35 0 top
NOREF#3056  -  []  137.62 122.05 0 top
NOREF#3057  -  []  26.37 0.56 90 top
NOREF#3058  -  []  124.66 131.39 0 top
NOREF#3059  -  []  87.22 91.77 0 top
NOREF#3060  -  []  125.02 45.2 90 top
NOREF#3061  -  []  75.01 102.03 0 top
NOREF#3062  -  []  2.24 66.75 0 top
NOREF#3063  -  []  127.91 54.86 0 top
NOREF#3064  -  []  65.23 177.47 0 top
NOREF#3065  -  []  94.39 37.52 0 top
NOREF#3066  -  []  138.91 74.88 90 top
NOREF#3067  -  []  130.78 63.24 0 top
NOREF#3068  -  []  142.19 136.32 0 top
NOREF#3069  -  []  88.39 90.75 0 top
NOREF#3070  -  []  108.07 33.65 90 top
NOREF#3071  -  []  149.2 73.2 0 top
NOREF#3072  -  []  134.52 56.29 0 top
NOREF#3073  -  []  131.04 72.09 0 top
NOREF#3074  -  []  134.4 144.91 0 top
NOREF#3075  -  []  2.03 14.1 0 top
NOREF#3076  -  []  118.44 35.51 0 top
NOREF#3077  -  []  126.23 30.86 0 top
NOREF#3078  -  []  102.57 64.06 270 top
NOREF#3079  -  []  52.7 32.42 0 top
NOREF#3080  -  []  142.19 132.92 0 top
NOREF#3081  -  []  139.37 33.39 90 top
NOREF#3082  -  []  101.22 18.41 90 top
NOREF#3083  -  []  119.96 170.13 0 top
NOREF#3084  -  []  34.75 26.43 270 top
NOREF#3085  -  []  91.62 35.51 90 top
NOREF#3086  -  []  134.95 127.3 0 top
NOREF#3087  -  []  82.3 35.97 90 top
NOREF#3088  -  []  134.95 86.56 90 top
NOREF#3089  -  []  56.46 149.3 0 top
NOREF#3090  -  []  48.03 74.19 0 top
NOREF#3091  -  []  96.25 59.31 0 top
NOREF#3092  -  []  56.12 36.27 0 top
NOREF#3093  -  []  22.05 38.9 90 top
NOREF#3094  -  []  17.98 34.4 90 top
NOREF#3095  -  []  149.66 69.6 0 top
NOREF#3096  -  []  67.82 26.29 0 top
NOREF#3097  -  []  12.01 109.32 90 top
NOREF#3098  -  []  135.17 40.06 0 top
NOREF#3099  -  []  53.85 58.29 270 top
NOREF#3100  -  []  99.48 91.64 90 top
NOREF#3101  -  []  90.13 107.62 0 top
NOREF#3102  -  []  17.73 108.92 0 top
NOREF#3103  -  []  90.83 98.91 90 top
NOREF#3104  -  []  59.25 25.63 0 top
NOREF#3105  -  []  89.79 107.92 0 top
NOREF#3106  -  []  45.49 70.48 270 top
NOREF#3107  -  []  54.86 17.4 90 top
NOREF#3108  -  []  101.98 63.75 90 top
NOREF#3109  -  []  135.15 88.65 0 top
NOREF#3110  -  []  2.92 67.09 0 top
NOREF#3111  -  []  36.83 127.86 270 top
NOREF#3112  -  []  19.76 34.43 0 top
NOREF#3113  -  []  36.32 35.97 90 top
NOREF#3114  -  []  60.85 34.52 270 top
NOREF#3115  -  []  156.54 181.69 90 top
NOREF#3116  -  []  58.43 113.37 270 top
NOREF#3117  -  []  66.88 27.7 270 top
NOREF#3118  -  []  110.36 25.26 90 top
NOREF#3119  -  []  142.04 71.58 90 top
NOREF#3120  -  []  137.24 45.2 0 top
NOREF#3121  -  []  8.87 0.16 0 top
NOREF#3122  -  []  57.78 52.81 270 top
NOREF#3123  -  []  130.94 141.95 270 top
NOREF#3124  -  []  80.35 37.95 0 top
NOREF#3125  -  []  140.63 47.5 0 top
NOREF#3126  -  []  92.38 102.08 0 top
NOREF#3127  -  []  115.76 25.65 0 top
NOREF#3128  -  []  108.74 158.75 0 top
NOREF#3129  -  []  99.62 91.68 90 top
NOREF#3130  -  []  155.5 100.96 270 top
NOREF#3131  -  []  58.04 72.14 90 top
NOREF#3132  -  []  158.8 57.37 270 top
NOREF#3133  -  []  126.9 99.57 0 top
NOREF#3134  -  []  45.42 215.26 0 top
NOREF#3135  -  []  125.7 72.31 0 top
NOREF#3136  -  []  50.06 50.06 0 top
NOREF#3137  -  []  59.64 109.74 0 top
NOREF#3138  -  []  16.78 36.4 90 top
NOREF#3139  -  []  142.19 134.92 0 top
NOREF#3140  -  []  34.79 30.48 0 top
NOREF#3141  -  []  145.29 173.2 270 top
NOREF#3142  -  []  98.6 95.61 90 top
NOREF#3143  -  []  138.81 30.99 90 top
NOREF#3144  -  []  68.33 6.91 90 top
NOREF#3145  -  []  97.66 96.91 270 top
NOREF#3146  -  []  134.11 53.07 90 top
NOREF#3147  -  []  127.2 75.49 0 top
NOREF#3148  -  []  134.37 149.22 0 top
NOREF#3149  -  []  76.33 18.38 270 top
NOREF#3150  -  []  98.81 64.64 0 top
NOREF#3151  -  []  65.67 25.78 90 top
NOREF#3152  -  []  130.63 127.3 0 top
NOREF#3153  -  []  131.5 88.39 0 top
NOREF#3154  -  []  102.18 28.33 0 top
NOREF#3155  -  []  104.43 26.04 0 top
NOREF#3156  -  []  140.39 179.82 90 top
NOREF#3157  -  []  127.99 65.86 0 top
NOREF#3158  -  []  117.84 34.52 0 top
NOREF#3159  -  []  17.86 80.29 90 top
NOREF#3160  -  []  76.89 105.97 270 top
NOREF#3161  -  []  47.96 140 0 top
NOREF#3162  -  []  40.13 25.67 90 top
NOREF#3163  -  []  130.68 140.97 90 top
NOREF#3164  -  []  107.82 33.52 90 top
NOREF#3165  -  []  49.81 105.56 0 top
NOREF#3166  -  []  35.64 18.72 0 top
NOREF#3167  -  []  17.86 81.92 0 top
NOREF#3168  -  []  131.34 73.37 270 top
NOREF#3169  -  []  146.71 87.67 90 top
NOREF#3170  -  []  28.85 168.02 270 top
NOREF#3171  -  []  60.01 113.07 270 top
NOREF#3172  -  []  57.86 83.91 270 top
NOREF#3173  -  []  45.16 45.92 0 top
NOREF#3174  -  []  23.06 38.9 90 top
NOREF#3175  -  []  58.05 92.9 0 top
NOREF#3176  -  []  109.68 27.17 0 top
NOREF#3177  -  []  149.05 151.18 0 top
NOREF#3178  -  []  130 37.58 90 top
NOREF#3179  -  []  134.44 130 0 top
NOREF#3180  -  []  119.32 109.22 0 top
NOREF#3181  -  []  35.67 192.48 0 top
NOREF#3182  -  []  124.09 45.93 90 top
NOREF#3183  -  []  75.13 37.21 270 top
NOREF#3184  -  []  119.2 154.36 270 top
NOREF#3185  -  []  137.16 36.35 90 top
NOREF#3186  -  []  33.35 41.45 0 top
NOREF#3187  -  []  47.8 146.13 90 top
NOREF#3188  -  []  140.59 183.13 90 top
NOREF#3189  -  []  157.07 110.69 0 top
NOREF#3190  -  []  52.7 32.14 90 top
NOREF#3191  -  []  46.81 34.24 90 top
NOREF#3192  -  []  6.17 73.46 0 top
NOREF#3193  -  []  50.52 52.15 0 top
NOREF#3194  -  []  54.56 40.94 270 top
NOREF#3195  -  []  79.18 26.26 270 top
NOREF#3196  -  []  63.74 29.21 0 top
NOREF#3197  -  []  42.21 99.92 90 top
NOREF#3198  -  []  107.19 33.52 90 top
NOREF#3199  -  []  110.99 36.27 0 top
NOREF#3200  -  []  20.83 77.32 270 top
NOREF#3201  -  []  17.65 34.43 0 top
NOREF#3202  -  []  126.24 77.83 270 top
NOREF#3203  -  []  140.03 77.93 90 top
NOREF#3204  -  []  57.96 98.76 0 top
NOREF#3205  -  []  134.48 34.85 0 top
NOREF#3206  -  []  114.38 133.68 0 top
NOREF#3207  -  []  128 31.75 0 top
NOREF#3208  -  []  134.09 68.78 0 top
NOREF#3209  -  []  122.1 154.76 0 top
NOREF#3210  -  []  151.21 135.71 90 top
NOREF#3211  -  []  43.68 18.41 90 top
NOREF#3212  -  []  99.55 51.83 90 top
NOREF#3213  -  []  45.42 67.36 270 top
NOREF#3214  -  []  37.97 36.31 90 top
NOREF#3215  -  []  149.05 150.32 90 top
NOREF#3216  -  []  126.67 78.28 270 top
NOREF#3217  -  []  45.76 63.5 0 top
NOREF#3218  -  []  92.28 59.89 90 top
NOREF#3219  -  []  60.82 63.83 0 top
NOREF#3220  -  []  132.72 175.01 90 top
NOREF#3221  -  []  29.32 29.65 90 top
NOREF#3222  -  []  38.8 104.47 90 top
NOREF#3223  -  []  114.68 134.96 270 top
NOREF#3224  -  []  151.08 74.73 270 top
NOREF#3225  -  []  53.54 113.37 270 top
NOREF#3226  -  []  127.75 142.93 0 top
NOREF#3227  -  []  124.98 33.86 90 top
NOREF#3228  -  []  152.02 139.98 90 top
NOREF#3229  -  []  55.07 193.42 90 top
NOREF#3230  -  []  145.64 100.51 0 top
NOREF#3231  -  []  90.87 99.16 0 top
NOREF#3232  -  []  99.81 64.65 90 top
NOREF#3233  -  []  47.37 31.62 90 top
NOREF#3234  -  []  88.9 33.52 90 top
NOREF#3235  -  []  123.39 170.13 0 top
NOREF#3236  -  []  144.98 102.95 0 top
NOREF#3237  -  []  53.04 30.62 270 top
NOREF#3238  -  []  116.19 34.47 0 top
NOREF#3239  -  []  55.42 26.68 270 top
NOREF#3240  -  []  70.52 108.58 0 top
NOREF#3241  -  []  67.69 57.4 270 top
NOREF#3242  -  []  119.08 87.71 0 top
NOREF#3243  -  []  81.99 29.07 0 top
NOREF#3244  -  []  137.47 133.88 0 top
NOREF#3245  -  []  17.13 37.01 0 top
NOREF#3246  -  []  119.18 27.75 270 top
NOREF#3247  -  []  19.25 127.3 0 top
NOREF#3248  -  []  34.75 32.12 0 top
NOREF#3249  -  []  60.87 69.22 0 top
NOREF#3250  -  []  6.63 108.36 0 top
NOREF#3251  -  []  70.49 108.33 90 top
NOREF#3252  -  []  118.54 24.54 90 top
NOREF#3253  -  []  30.89 192.66 270 top
NOREF#3254  -  []  49.63 96.09 0 top
NOREF#3255  -  []  122.3 170.43 90 top
NOREF#3256  -  []  140.59 47.75 0 top
NOREF#3257  -  []  34.75 29.98 270 top
NOREF#3258  -  []  98.55 36.06 90 top
NOREF#3259  -  []  144.4 17.44 90 top
NOREF#3260  -  []  99.87 139.88 270 top
NOREF#3261  -  []  142.06 178.49 270 top
NOREF#3262  -  []  22.81 38.86 90 top
NOREF#3263  -  []  66.84 101.05 270 top
NOREF#3264  -  []  138.25 83.64 0 top
NOREF#3265  -  []  92.33 12.4 270 top
NOREF#3266  -  []  60.15 25.67 90 top
NOREF#3267  -  []  89.61 30.34 0 top
NOREF#3268  -  []  54.31 18.72 0 top
NOREF#3269  -  []  83.46 108.76 0 top
NOREF#3270  -  []  127.66 72.39 0 top
NOREF#3271  -  []  100.46 34.48 270 top
NOREF#3272  -  []  108.87 0.16 0 top
NOREF#3273  -  []  133.86 183.17 90 top
NOREF#3274  -  []  73.63 56.46 0 top
NOREF#3275  -  []  56.72 77.85 270 top
NOREF#3276  -  []  99.01 35.51 0 top
NOREF#3277  -  []  103.45 27.7 270 top
NOREF#3278  -  []  97.16 139.42 270 top
NOREF#3279  -  []  120.51 33.15 0 top
NOREF#3280  -  []  73.18 56.03 0 top
NOREF#3281  -  []  82.31 34.52 270 top
NOREF#3282  -  []  122.38 78.28 270 top
NOREF#3283  -  []  128 30.99 0 top
NOREF#3284  -  []  108.18 31.79 270 top
NOREF#3285  -  []  141.27 61.21 0 top
NOREF#3286  -  []  133.68 176.73 0 top
NOREF#3287  -  []  129.78 24.18 0 top
NOREF#3288  -  []  129.51 55.12 0 top
NOREF#3289  -  []  132.36 56.29 90 top
NOREF#3290  -  []  62.69 177.47 0 top
NOREF#3291  -  []  144.07 135.46 90 top
NOREF#3292  -  []  75.46 105.03 0 top
NOREF#3293  -  []  84.87 2.26 90 top
NOREF#3294  -  []  85.17 27.42 0 top
NOREF#3295  -  []  110.11 139.67 270 top
NOREF#3296  -  []  84.41 98.9 0 top
NOREF#3297  -  []  20.9 73.2 270 top
NOREF#3298  -  []  70.76 108.97 0 top
NOREF#3299  -  []  144.98 192.33 0 top
NOREF#3300  -  []  129.41 36.69 90 top
NOREF#3301  -  []  83.93 28.19 0 top
NOREF#3302  -  []  110.22 23.8 0 top
NOREF#3303  -  []  57.35 51.38 0 top
NOREF#3304  -  []  102.49 30.65 90 top
NOREF#3305  -  []  55.5 23.76 270 top
NOREF#3306  -  []  17.91 53.89 0 top
NOREF#3307  -  []  46.05 70.17 90 top
NOREF#3308  -  []  109.6 152.91 90 top
NOREF#3309  -  []  46.76 109.86 270 top
NOREF#3310  -  []  108.48 151.64 0 top
NOREF#3311  -  []  97.54 91.68 90 top
NOREF#3312  -  []  98.73 139.88 270 top
NOREF#3313  -  []  80.47 18.72 0 top
NOREF#3314  -  []  123.7 25.78 90 top
NOREF#3315  -  []  65.82 177.04 0 top
NOREF#3316  -  []  89.78 36.63 270 top
NOREF#3317  -  []  66.79 176.79 90 top
NOREF#3318  -  []  146.3 178.79 270 top
NOREF#3319  -  []  67.89 152.45 0 top
NOREF#3320  -  []  115.77 73.53 0 top
NOREF#3321  -  []  137.77 40.21 90 top
NOREF#3322  -  []  129.53 44.02 90 top
NOREF#3323  -  []  135.22 39.14 270 top
NOREF#3324  -  []  61.14 53.09 0 top
NOREF#3325  -  []  127.38 177.38 270 top
NOREF#3326  -  []  36.16 193.5 270 top
NOREF#3327  -  []  18.67 178.94 0 top
NOREF#3328  -  []  59.66 73.33 0 top
NOREF#3329  -  []  21.74 40.18 0 top
NOREF#3330  -  []  95.12 109.45 270 top
NOREF#3331  -  []  28.71 29.65 0 top
NOREF#3332  -  []  158.39 111.76 90 top
NOREF#3333  -  []  93.97 91.39 0 top
NOREF#3334  -  []  47.4 186.98 90 top
NOREF#3335  -  []  148.72 134.09 270 top
NOREF#3336  -  []  133.53 87 0 top
NOREF#3337  -  []  141.3 101.9 270 top
NOREF#3338  -  []  123.77 101.78 270 top
NOREF#3339  -  []  103.18 64.81 90 top
NOREF#3340  -  []  19.56 38.89 90 top
NOREF#3341  -  []  157 183.26 0 top
NOREF#3342  -  []  157.07 111.71 0 top
NOREF#3343  -  []  100.03 102.16 270 top
NOREF#3344  -  []  62.1 65.15 270 top
NOREF#3345  -  []  14.81 109.19 90 top
NOREF#3346  -  []  134.52 70.36 0 top
NOREF#3347  -  []  54.31 17.09 90 top
NOREF#3348  -  []  118.87 35.97 90 top
NOREF#3349  -  []  107.68 33.48 0 top
NOREF#3350  -  []  141.48 103.85 270 top
NOREF#3351  -  []  40.13 35.89 90 top
NOREF#3352  -  []  140.59 50.8 0 top
NOREF#3353  -  []  97.4 91.64 0 top
NOREF#3354  -  []  134.95 102.67 0 top
NOREF#3355  -  []  84.07 57.1 90 top
NOREF#3356  -  []  49.81 104.52 0 top
NOREF#3357  -  []  134.37 44.59 270 top
NOREF#3358  -  []  46.01 138.43 0 top
NOREF#3359  -  []  122.56 171.41 270 top
NOREF#3360  -  []  111.49 23.8 270 top
NOREF#3361  -  []  126.19 28.44 0 top
NOREF#3362  -  []  83.06 51.08 90 top
NOREF#3363  -  []  145.44 191.9 0 top
NOREF#3364  -  []  138.33 107.24 90 top
NOREF#3365  -  []  5.13 116.76 90 top
NOREF#3366  -  []  52.96 55.85 270 top
NOREF#3367  -  []  49.48 104.83 0 top
NOREF#3368  -  []  140.16 106.93 90 top
NOREF#3369  -  []  54.53 53.14 270 top
NOREF#3370  -  []  30.89 192.05 0 top
NOREF#3371  -  []  139.37 184.45 270 top
NOREF#3372  -  []  120.7 182.04 270 top
NOREF#3373  -  []  62.1 83.91 270 top
NOREF#3374  -  []  140.28 53.29 90 top
NOREF#3375  -  []  112.13 23.8 0 top
NOREF#3376  -  []  140.03 104.19 0 top
NOREF#3377  -  []  33.26 33.48 0 top
NOREF#3378  -  []  51.94 12.4 270 top
NOREF#3379  -  []  56.85 37.21 270 top
NOREF#3380  -  []  152.86 141.27 0 top
NOREF#3381  -  []  120.42 34.67 0 top
NOREF#3382  -  []  140.54 126.19 0 top
NOREF#3383  -  []  34.28 36.63 270 top
NOREF#3384  -  []  14.61 106.58 90 top
NOREF#3385  -  []  58.57 84.25 270 top
NOREF#3386  -  []  126.57 50.81 0 top
NOREF#3387  -  []  142.72 94.44 90 top
NOREF#3388  -  []  85.52 101.98 0 top
NOREF#3389  -  []  131.11 163.5 270 top
NOREF#3390  -  []  124.21 181.74 270 top
NOREF#3391  -  []  76.58 18.41 270 top
NOREF#3392  -  []  45.72 67.31 0 top
NOREF#3393  -  []  62.56 101.55 90 top
NOREF#3394  -  []  45.55 177.24 90 top
NOREF#3395  -  []  51.57 101.66 0 top
NOREF#3396  -  []  129.07 131.43 90 top
NOREF#3397  -  []  85.48 101.86 90 top
NOREF#3398  -  [unnamed#2]  155 5 0 top
NOREF#3399  -  []  70.18 108.89 270 top
NOREF#3400  -  []  104.09 25.73 0 top
NOREF#3401  -  []  139.34 40.67 90 top
NOREF#3402  -  []  134.05 26.04 90 top
NOREF#3403  -  []  122.22 133.05 90 top
NOREF#3404  -  []  150.14 15.57 0 top
NOREF#3405  -  []  30.18 36.53 0 top
NOREF#3406  -  []  131.8 85.29 0 top
NOREF#3407  -  []  99.21 110.36 0 top
NOREF#3408  -  []  140.59 178.82 90 top
NOREF#3409  -  []  39.9 62.23 0 top
NOREF#3410  -  []  137.07 76.33 0 top
NOREF#3411  -  []  91.26 38.3 90 top
NOREF#3412  -  []  43.43 62.1 90 top
NOREF#3413  -  []  45.72 61.09 0 top
NOREF#3414  -  []  140.64 27.17 90 top
NOREF#3415  -  []  120.62 71.02 90 top
NOREF#3416  -  []  134.75 184.15 270 top
NOREF#3417  -  []  42.11 123.9 0 top
NOREF#3418  -  []  17.51 39.55 270 top
NOREF#3419  -  []  62.94 188.16 0 top
NOREF#3420  -  []  53.21 73.14 90 top
NOREF#3421  -  []  137.39 89.23 0 top
NOREF#3422  -  []  49.21 109.6 0 top
NOREF#3423  -  []  122.38 158.7 0 top
NOREF#3424  -  []  149.43 134.54 0 top
NOREF#3425  -  []  21.8 39.87 90 top
NOREF#3426  -  []  92.7 36.27 0 top
NOREF#3427  -  []  11.84 20.47 90 top
NOREF#3428  -  []  149.12 131.11 270 top
NOREF#3429  -  []  85.88 177.29 0 top
NOREF#3430  -  []  5.08 -25.4 0 top
NOREF#3431  -  []  20.71 39.19 90 top
NOREF#3432  -  []  70.33 81.48 0 top
NOREF#3433  -  []  51.61 102.57 0 top
NOREF#3434  -  []  137.24 45.2 90 top
NOREF#3435  -  []  91.39 30.47 90 top
NOREF#3436  -  []  121.08 28.05 90 top
NOREF#3437  -  []  68.83 182.25 90 top
NOREF#3438  -  []  66.88 94.31 0 top
NOREF#3439  -  []  128.02 165.82 270 top
NOREF#3440  -  []  115.52 120.12 90 top
NOREF#3441  -  []  100.69 24.99 90 top
NOREF#3442  -  []  17.98 30.62 0 top
NOREF#3443  -  []  83.16 108.2 0 top
NOREF#3444  -  []  52.73 78.16 0 top
NOREF#3445  -  []  75.77 52.27 90 top
NOREF#3446  -  []  49.49 109.6 270 top
NOREF#3447  -  []  50.85 26.34 270 top
NOREF#3448  -  []  140.16 72.72 0 top
NOREF#3449  -  []  99.81 65.66 90 top
NOREF#3450  -  []  6.79 164.46 90 top
NOREF#3451  -  []  57.26 23.8 270 top
NOREF#3452  -  []  144.86 176.23 90 top
NOREF#3453  -  []  27.93 37.39 0 top
NOREF#3454  -  []  114.25 25.69 90 top
NOREF#3455  -  []  7.32 73.46 0 top
NOREF#3456  -  []  57.87 95.57 0 top
NOREF#3457  -  []  55.98 84.25 270 top
NOREF#3458  -  []  110.03 65.61 90 top
NOREF#3459  -  []  52.73 78.16 270 top
NOREF#3460  -  []  116.89 154.38 0 top
NOREF#3461  -  []  135.94 71.07 90 top
NOREF#3462  -  []  129.15 24.18 0 top
NOREF#3463  -  []  136.73 35.89 0 top
NOREF#3464  -  []  92.2 36.31 90 top
NOREF#3465  -  []  56.95 82.93 90 top
NOREF#3466  -  []  146.56 130.77 270 top
NOREF#3467  -  []  134.52 71.5 0 top
NOREF#3468  -  []  127.18 143.94 270 top
NOREF#3469  -  []  34.79 28.83 0 top
NOREF#3470  -  []  82.03 26.85 0 top
NOREF#3471  -  []  45.72 66.8 90 top
NOREF#3472  -  []  60.83 68.96 0 top
NOREF#3473  -  []  61.4 91.68 0 top
NOREF#3474  -  []  140.59 46.35 0 top
NOREF#3475  -  []  43 68.76 0 top
NOREF#3476  -  []  137.11 86.56 90 top
NOREF#3477  -  []  50.42 76.07 270 top
NOREF#3478  -  []  21.41 77.77 0 top
NOREF#3479  -  []  110.57 127.58 0 top
NOREF#3480  -  []  51.57 102.43 0 top
NOREF#3481  -  []  53.85 146.18 90 top
