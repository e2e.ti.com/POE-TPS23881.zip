# Allegro board POE TPS23881.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VCC5_USB3 on TOP: 68.07,46.81 62.07,46.81 62.05,46.81 62.04,46.8 61.81,46.57 61.8,46.56 61.8,46.54 61.8,43.38 61.62,43.2 58.44,43.2 58.33,43.31 58.3,43.33 58.17,43.47 58.17,49.59 58.17,49.6 58.18,49.62 58.74,50.18 58.75,50.19 58.75,50.21 58.75,51.64 59.18,52.07 62.1,52.07 62.99,52.96 68.96,52.96 69.09,52.83 69.09,47.83
VCC25P on TOP: 68.4,98.12 74.04,98.12 74.75,97.41 74.75,94.67 74.65,94.56 73.69,94.56 73.18,95.07 70.05,95.07 69.8,94.82 69.8,93.42 69.67,93.29 68.15,93.29 68.15,97.87
VCC25P on TOP: 46.05,90.37 49.1,90.37 49.23,90.25 49.23,88.09 49.1,87.96 46.18,87.96 45.92,88.21 45.92,90.25
VCC25P on IN2: 53.92,58.37 59.51,58.37 60.4,59.26 60.4,60.4 60.66,60.66 60.66,63.45 59.64,64.47 59.64,65.86 60.02,66.24 62.69,66.24 63.32,66.88 63.32,77.42 74.7,88.8 74.7,100.97 74.07,101.6 52.96,101.6 49.61,98.25 49.61,92.79 45.67,88.85 45.67,72.47 46.2,71.93 48.06,71.93 48.21,72.09 52.91,72.09 53.16,71.83 53.16,70.31 47.32,64.47 47.32,60.02 47.83,59.51 52.78,59.51
VCC_DCIN on TOP: 10.03,119.38 9.91,119.25 5.33,119.25 5.21,119.38 5.21,127.13 5.46,127.38 9.91,127.38 10.03,127.25
VCC_DCIN on TOP: 35,175.69 36.07,174.62 36.07,168.28 37.39,166.95 38.86,166.95 38.99,166.83 38.99,166.45 38.89,166.34 38.89,166.01 40.64,164.26 40.64,158.5 40.51,158.37 25.91,158.37 25.15,159.13 25.15,175.18 25.65,175.69
VCC_DCIN on BOTTOM: 35.89,174.45 36.14,174.19 36.14,157.94 36.02,157.81 33.1,157.81 32.46,157.18 32.46,137.87 31.32,136.73 11.05,136.73 9.68,135.36 9.68,119.46 9.42,119.2 5.92,119.2 5.79,119.33 5.79,149.81 10.11,154.13 22.68,154.13 25.35,156.79 25.35,167.69 23.01,170.03 23.01,171.96 22.38,172.59 22.38,177.8 21.49,178.69 21.49,180.21 21.62,180.34 22.5,180.34 23.9,178.94 26.44,178.94 27.46,177.93 27.46,175.51 28.52,174.45
VCC_DCIN on IN1: 35.31,174.35 35.31,160.3 30.53,155.52 30.53,154.28 29.87,153.62 29.16,153.62 11.33,135.79 11.33,130.33 10.03,129.03 10.03,119.68 9.68,119.33 3.51,119.33 3.23,119.61 3.23,151.69 7.89,156.35 7.89,166.64 9.35,168.1 20.7,168.1 22.69,170.09 22.69,172.35 24.99,174.65 35,174.65
VCC_DCIN on IN2: 35.31,168.3 35.31,160.2 9.86,134.75 9.86,119.46 9.73,119.33 5.33,119.33 5.08,119.58 5.08,153.54 9.92,158.38 9.92,162.7 15.99,168.77 22.09,168.77 22.68,169.37 34.24,169.37
VCC_DCIN on VCC: 25.51,177.55 33.17,177.55 35.81,174.9 35.81,159.87 24.84,148.9 24.78,148.81 24.77,148.72 24.77,138.56 14.61,138.56 14.51,138.54 14.43,138.48 11.76,135.82 11.7,135.73 11.68,135.64 11.68,131.04 9.98,129.34 9.93,129.26 9.91,129.16 9.91,119.49 9.67,119.25 0.61,119.25 0.56,119.31 0.54,119.33 0.51,119.35 0.51,152.65 3.94,152.65 4.03,152.67 4.12,152.73 10.85,159.46 10.9,159.54 10.92,159.64 10.92,163.72 13.31,166.12 16,166.12 16.1,166.14 16.18,166.19 19.1,169.11 19.16,169.19 19.18,169.29 19.18,171.73 20.93,173.48 24.51,173.48 24.61,173.5 24.69,173.56 25.07,173.94 25.13,174.02 25.15,174.12 25.15,177.19
VCC_DCIN on IN3: 27.69,174.62 36.07,174.62 36.45,174.24 36.45,160.91 9.91,134.37 9.91,119.51 9.65,119.25 5.71,119.25 5.46,119.51 5.46,140.92 26.54,162 26.54,173.48
VCC_SRC on TOP: 45.34,132.21 51.82,132.21 52.07,131.95 52.07,131.11 51.66,130.71 51.66,129.54 52.01,129.2 52.01,128.13 51.36,127.48 51.36,126.59 51.49,126.47 51.79,126.47 51.99,126.26 51.99,125.02 51.64,124.66 51.64,123.67 51.97,123.34 51.97,122.1 51.44,121.56 51.44,120.75 51.99,120.19 51.99,119.2 51.87,119.08 44.88,119.08 44.7,119.25 44.7,131.57
VCC_SRC on TOP: 108.58,131.44 116.46,131.44 116.59,131.32 116.59,127.58 113.49,124.49 113.49,119.13 113.11,118.75 108.33,118.75 107.95,119.13 107.95,130.81
VCC_SRC on TOP: 59.18,157.86 62.61,157.86 62.74,157.73 62.74,150.24 62.43,149.94 59,149.94 58.75,150.19 58.75,156.24 59.05,156.54 59.05,157.73
VCC_SRC on TOP: 55.63,180.85 59.18,180.85 59.44,180.59 59.44,174.62 59.31,174.5 53.21,174.5 52.45,175.26 50.8,175.26 50.55,175.51 50.55,177.16 50.8,177.42 52.2,177.42
VCC_SRC on TOP: 5.56,111.79 7.19,111.79 7.24,111.73 7.24,110.57 7.16,110.49 5.54,110.49 5.46,110.57 5.46,111.68
VCC_SRC on TOP: 71.65,181.71 75.9,181.71 76.68,180.92 76.68,178.03 77.19,177.52 78.69,177.52 78.92,177.29 78.92,175.01 78.71,174.8 77.17,174.8 75.9,173.53 70.18,173.53 69.98,173.74 69.98,175.13 70.23,175.39 72.44,175.39 73.3,176.25 73.3,177.88 71.55,179.63 71.55,181.61
VCC_SRC on BOTTOM: 52.02,132.38 52.22,132.18 52.22,119.61 52.04,119.43 45.11,119.43 44.7,119.84 44.7,130.94 44.96,131.19 47.12,131.19 48.31,132.38
VCC_SRC on IN1: 5.36,111.99 6.93,111.99 7.04,111.89 7.04,110.41 6.88,110.26 4.98,110.26 4.7,110.54 4.7,111.33
VCC_SRC on IN1: 48.9,177.19 52.45,177.19 52.68,176.96 52.68,175.08 52.43,174.83 51.03,174.83 49.99,173.79 39.62,173.79 37.92,175.49 24.94,175.49 18.8,181.64 5.18,181.64 4.7,182.12 4.7,185.95 1.91,188.75 1.91,189.56 2.11,189.76 3.91,189.76 6.45,187.22 6.45,185.01 7.82,183.64 19.02,183.64 25.53,177.14 41.83,177.14 43.56,175.41 47.12,175.41
VCC_SRC on IN2: 78.38,181.48 79.83,180.04 79.83,174.96 78.31,173.43 50.22,173.43 49.35,174.29 49.35,179.83 50.09,180.57 59.36,180.57 59.77,180.16 69.55,180.16 70.87,181.48
VCC_SRC on VCC: outline of 116 points within 25.27,107.7 115.44,184.53
VDD105 on IN2: 60.02,65.48 62.94,65.48 63.2,65.23 63.2,55.93 62.51,55.24 47.4,55.24 42.75,59.89 42.75,63.14 47.83,68.22 47.83,70.82 48.69,71.68 52.43,71.68 52.53,71.58 52.53,70.43 46.94,64.85 46.94,59.77 47.57,59.13 52.15,59.13 53.16,58.12 59.64,58.12 61.04,59.51 61.04,63.83 59.89,64.97 59.89,65.35
VDD105P on TOP: 46.05,100.03 49.1,100.03 49.23,99.9 49.23,97.74 49.1,97.61 46.18,97.61 45.92,97.87 45.92,99.9
VDD105P on TOP: 66.12,92.79 66.93,92.79 67.03,92.89 67.03,96.75 66.52,97.26 66.52,97.79 66.5,97.82 66.07,97.82 66.01,97.76 66.01,92.89
VDD105P on TOP: 44.91,59.18 44.91,60.27 45,60.37 45.09,60.36 45.76,60.36 45.86,60.37 45.97,60.4 46.18,60.4 46.3,60.53 46.3,60.99 46.61,61.29 47.83,61.29 48.08,61.04 48.08,59.49 47.9,59.31 46,59.31 45.75,59.05 45.03,59.05
VDD105P on TOP: 52.16,102.93 52.18,102.94 52.21,102.95 58.5,102.95 58.62,102.82 58.62,101.93 58.83,101.73 59.39,101.73 59.46,101.65 59.46,97.59 59.56,97.49 59.56,94.56 59.36,94.36 58.47,94.36 58.29,94.54 58.29,100.63 58.15,100.77 52.08,100.77 51.99,100.86 51.99,102.8 52.12,102.93
VDD105P on VCC: 54.08,107.7 64.16,107.7 64.9,106.96 64.9,103.12 64.92,103.03 64.97,102.94 69.04,98.88 69.12,98.83 69.22,98.81 75.06,98.81 75.06,80.75 74.62,80.32 74.57,80.23 74.55,80.14 74.55,74.4 70.13,69.98 52.81,69.98 52.07,70.72 52.07,72.16 52.63,72.72 52.69,72.8 52.7,72.9 52.7,74.32 53.27,74.88 53.32,74.96 53.34,75.06 53.34,77.22 53.32,77.31 53.27,77.4 52.58,78.08 52.58,79.12 52.56,79.22 52.5,79.3 50.42,81.39 50.42,91.44 50.4,91.54 50.34,91.62 48.31,93.65 48.23,93.71 48.13,93.73 46.59,93.73 45.97,94.34 45.97,99.21 46.71,99.95 48.26,99.95 48.36,99.97 48.44,100.02 48.82,100.4 48.88,100.49 48.9,100.58 48.9,107.19 53.47,107.19 53.56,107.21 53.65,107.26
VDD105P on IN3: 60.91,70.89 60.91,59 60.4,58.5 51.46,58.5 49.89,60.07 47.45,60.07 47.29,60.22 47.29,67.36 47.96,68.02 47.96,71.25 48.39,71.68 60.12,71.68
VDD_1V8_CDC on TOP: 135,151.51 136.91,151.51 137.54,150.88 140.72,150.88 140.84,150.75 140.84,150.24 140.72,150.11 137.79,150.11 137.41,149.73 135.13,149.73 135,149.86
VDDE_A on TOP (solid shape): 101.63,92.84 101.63,91.31 101.5,91.19 100.53,91.19 100.41,91.31 100.41,91.8 100.53,91.92 100.53,92.84 100.66,92.96 101.5,92.96
VDDE_A on IN1: 89.99,79.38 89.74,79.12 87.78,79.12 86.39,80.52 86.39,89.15 87.4,90.17 91.44,90.17 92.58,89.03 98.3,89.03 98.42,89.15 98.42,89.69 100.51,91.77 101.42,91.77 101.63,91.57 101.63,90.55 100.1,89.03 100.1,87.63 100.3,87.43 100.3,86.44 98.68,84.81 91.87,84.81 91.02,83.96 91.02,81.62 89.99,80.59
51770_AGND on BOTTOM (solid shape): 20.4,114.07 20.4,110.06 20.27,109.93 9.68,109.93 9.12,110.49 8.15,110.49 7.95,110.69 7.95,115.14 8.2,115.39 19.08,115.39
51770_AGND on IN1 (solid shape): 20.32,112.5 20.32,110.82 20.12,110.62 9.17,110.62 8.94,110.85 8.94,113.82 9.17,114.05 18.77,114.05
51770_AGND on IN2 (solid shape): 20.32,112.5 20.32,110.82 20.12,110.62 9.17,110.62 8.94,110.85 8.94,113.82 9.17,114.05 18.77,114.05
51770_AGND on IN3 (solid shape): 20.32,112.5 20.32,110.82 20.12,110.62 9.17,110.62 8.94,110.85 8.94,113.82 9.17,114.05 18.77,114.05
51770_VCC on TOP: 12.14,118.31 13.08,118.31 13.16,118.24 13.16,117.91 12.9,117.65 12.9,117.17 12.78,117.04 12.14,117.04 12.01,117.17 12.01,118.19
51770_VCC on BOTTOM: 15.32,119.71 15.44,119.58 15.44,117.17 15.19,116.92 12.14,116.92 12.01,117.04 12.01,119.58 12.14,119.71
ASM_VCC33 on TOP (solid shape): outline of 190 points within 40.03,82.3 69.19,95.81
ASM_VCC33 on BOTTOM: 49.5,47.32 50.77,47.32 50.83,47.27 50.83,46.58 50.93,46.48 54.08,46.48 54.13,46.43 54.13,45.49 54,45.36 49.5,45.36 49.33,45.54 49.33,47.14
ASM_VCC33 on IN1: 52.27,46.05 51.51,45.29 44.02,45.29 42.88,46.43 34.24,46.43 32.59,48.08 32.59,67.01 35.76,70.18 35.76,82.37 37.8,84.4 46.18,84.4 47.45,83.13 47.45,78.94 49.73,76.66 49.73,73.23 51.84,71.12 51.84,69.75 52.1,69.49 59.82,69.49 60.4,68.91 60.4,66.12 59.39,65.1 43.64,65.1 42.24,66.5 38.18,66.5 37.41,65.74 37.41,59.64 37.92,59.13 42.24,59.13 42.49,58.88 48.97,58.88 49.23,59.13 49.99,59.13 52.27,56.85
ASM_VCC33 on IN3: 67.77,101.3 74.88,101.3 75.59,100.58 75.59,78.28 75.39,78.08 74.7,78.08 74.19,78.59 74.19,79.78 73.23,80.75 69.27,80.75 69.01,81 69.01,84.4 66.7,86.72 66.7,88.9 66.5,89.1 56.08,89.1 56.03,89.15 52.73,89.15 52.4,89.48 52.4,91.64 52.46,91.71 52.46,95.49 53.87,96.9 67.34,96.9 67.51,97.08 67.51,101.04
CAN_REF on TOP: 36.58,188.21 38.73,188.21 38.86,188.34 38.86,189.74 39.37,190.25 41.53,190.25 41.78,190.5 41.78,192.41 41.66,192.53 40.59,192.53 40.39,192.74 40.34,192.74 40.34,194.39 39.95,194.77 30.94,194.77 30.05,193.88 30.05,188.42 30.18,188.29 30.81,188.29 30.94,188.42 30.94,190.45 31.57,191.08 31.57,193.5 31.83,193.75 36.27,193.75 36.45,193.57 36.45,188.34
CAN_REF on BOTTOM: 40.39,191.01 40.26,190.88 38.1,190.88 37.97,191.01 37.97,194.44 38.61,195.07 38.61,198.12 38.86,198.37 40.13,198.37 40.39,198.12
CASE1_GND on TOP: 24.26,198.5 30.23,198.5 30.35,198.37 30.35,196.8 29.39,195.83 24.26,195.83 24.13,195.96 24.13,198.37
CASE1_GND on BOTTOM: 30.23,198.5 30.35,198.37 30.35,195.96 30.23,195.83 23.88,195.83 23.75,195.96 23.75,198.25 24,198.5
HDMI_GND on TOP (solid shape): outline of 469 points within 92.79,40.21 110.82,50.37
ISO12_REF on TOP: 42.8,189.87 42.55,189.61 39.62,189.61 39.37,189.36 39.37,184.12 39.47,184.02 42.09,184.02 42.29,184.23 42.29,187.45 42.55,187.71 52.83,187.71 53.35,188.23 53.35,190.39 55.37,192.41 55.37,198.37 55.24,198.5 43.18,198.5 42.8,198.12
ISO12_REF on BOTTOM: 41.02,193.55 45.97,193.55 46.23,193.29 46.23,189.87 45.97,189.61 41.02,189.61 40.89,189.74 40.89,193.42
ISO_+V12S on IN1 (solid shape): outline of 653 points within 40.77,183.13 61.34,198.37
ISO_+V12S on IN2 (solid shape): outline of 663 points within 40.77,183.13 61.34,198.5
ISO_+V12S on IN3 (solid shape): outline of 663 points within 40.77,183.13 61.34,198.5
ISO_+V12S on TOP: 59.82,198.5 61.21,198.5 61.34,198.37 61.34,197.96 61.29,197.76 61.28,197.56 61.29,197.36 61.34,197.17 61.34,193.42 59.94,192.02 59.94,183.39 59.69,183.13 43.43,183.13 42.93,183.64 42.93,186.94 43.18,187.2 53.26,187.2 53.92,186.35 54.94,186.03 56.04,186.4 56.68,187.36 56.69,187.37 57.02,187.71 57.02,190.5 57.78,191.26 57.78,194.06 59.69,195.96 59.69,197 59.79,197.28 59.82,197.56 59.79,197.84 59.7,198.11 59.69,198.12 59.69,198.37
ISO_+V12S on BOTTOM: 52.96,187.2 53.34,186.82 53.34,185.29 53.72,184.91 56.13,184.91 56.77,185.55 59.18,185.55 59.44,185.29 59.44,183.51 59.05,183.13 43.43,183.13 41.02,185.55 41.02,188.34 41.15,188.47 43.43,188.47 43.56,188.34 43.56,187.83 43.69,187.71 43.69,187.07 44.45,186.31 46.74,186.31 47.62,187.2
ISO_GND on BOTTOM (solid shape): 100.58,198.98 75.5,198.98 75.5,199.49 100.58,199.49
ISO_GND on TOP: 69.47,192.66 74.8,192.66 77.34,190.12 78.74,190.12 78.87,189.99 78.87,188.09 78.74,187.96 75.69,187.96 74.3,189.36 69.34,189.36 69.22,189.48 69.22,192.41
ISO_GND on TOP: 68.83,183.77 70.74,183.77 70.87,183.9 70.87,186.18 70.74,186.31 68.83,186.31 68.71,186.18 68.71,183.9
ISO_GND on BOTTOM: 68.45,192.66 74.8,192.66 77.34,190.12 78.74,190.12 78.87,189.99 78.87,188.09 78.74,187.96 75.69,187.96 74.3,189.36 68.07,189.36 67.94,189.48 67.94,192.15
ISO_GND on GND1: 24.64,199.49 100.58,199.49 100.58,193.06 91.55,184.02 63.37,184.02 62.89,183.93 62.47,183.65 61.96,183.13 43.2,183.13 42.55,183.78 42.14,184.05 41.66,184.15 37.61,184.15 35.06,186.7 34.65,186.97 34.16,187.07 27.7,187.07 24.64,190.14 24.64,191.57 24.64,191.63 24.63,191.69 24.63,192.11 23.77,192.97 23.77,195 24.32,195.55 24.32,198.04 24.38,198.12 24.64,198.37
ISO_GND on VCC, GND2: 24.64,199.49 100.58,199.49 100.58,193.06 91.55,184.02 63.37,184.02 62.89,183.93 62.47,183.65 61.96,183.13 43.2,183.13 42.55,183.78 42.14,184.05 41.66,184.15 37.61,184.15 35.06,186.7 34.65,186.97 34.16,187.07 27.7,187.07 24.64,190.14
LAN1_CT1_A+_V- on TOP: 12.01,13.03 12.14,12.9 12.14,11.63 11.76,11.25 11.76,9.22 11.63,9.09 10.24,9.09 8.59,10.74 6.05,10.74 5.92,10.87 5.92,13.54 6.05,13.67 8.46,13.67 9.09,13.03
LAN1_CT1_A+_V- on BOTTOM: 11.76,10.82 11.76,5.92 11.63,5.79 9.98,5.79 9.86,5.92 9.86,10.79 9.98,10.92 11.66,10.92
LAN1_CT2_A-_V+ on TOP: 13.41,13.03 15.57,13.03 15.7,12.9 15.7,9.6 15.57,9.47 14.68,9.47 14.05,10.11 14.05,10.87 13.28,11.63 13.28,12.9
LAN1_CT2_A-_V+ on BOTTOM: 15.82,8.84 15.47,8.48 14.96,8.48 12.06,11.38 9.22,11.38 8.59,10.74 6.05,10.74 5.92,10.87 5.92,13.54 6.05,13.67 8.59,13.67 9.3,12.95 15.52,12.95 15.82,12.65
LAN1_CT3_B+_V+ on TOP: 17.98,13.03 19.76,13.03 19.89,12.9 19.89,9.47 19.76,9.35 17.98,9.35 17.86,9.47 17.86,12.9
LAN1_CT3_B+_V+ on TOP: 8.59,9.73 8.59,6.43 8.46,6.3 5.92,6.3 5.79,6.43 5.79,9.86 5.92,9.98 8.33,9.98
LAN1_CT3_B+_V+ on BOTTOM: 17.98,11.89 19.76,11.89 19.89,11.76 19.89,9.14 19.08,8.33 18.64,8.33 17.86,9.12 17.86,11.76
LAN1_CT3_B+_V+ on IN1: 17.73,11.63 20.14,11.63 20.27,11.51 20.27,9.09 20.02,8.84 6.17,8.84 6.05,8.97 6.05,10.49 6.3,10.74 16.84,10.74
LAN1_CT4_B-_V- on TOP: 22.3,12.9 23.83,12.9 23.95,12.78 23.95,9.47 23.83,9.35 22.3,9.35 22.17,9.47 22.17,12.78
LAN1_CT4_B-_V- on BOTTOM: 8.59,9.09 8.59,5.54 8.46,5.41 5.92,5.41 5.79,5.54 5.79,9.09 5.92,9.22 8.46,9.22
LAN1_CT4_B-_V- on BOTTOM: 22.3,11.89 23.83,11.89 23.95,11.76 23.95,9.35 23.01,8.41 22.48,8.41 22.17,8.71 22.17,11.76
LAN1_CT4_B-_V- on IN1: 21.29,11.63 24.21,11.63 24.46,11.38 24.46,6.43 23.32,5.28 6.17,5.28 5.92,5.54 5.92,8.08 6.05,8.2 20.4,8.2 21.03,8.84 21.03,11.38
LAN2_CT1_A+_V- on TOP: 34.42,11.96 33.71,11.25 33.71,9.37 33.6,9.27 32.16,9.27 30.78,10.64 28.47,10.64 28.37,10.74 28.37,12.9 28.42,12.95 34.32,12.95 34.42,12.85
LAN2_CT1_A+_V- on BOTTOM: 34.72,10.79 34.72,7.92 34.67,7.87 33.53,7.87 31.98,9.42 31.98,10.82 32.11,10.95 34.57,10.95
LAN2_CT2_A-_V+ on TOP: 38.46,11.61 37.77,10.92 37.77,9.47 37.72,9.42 36.42,9.42 36.32,9.53 36.32,12.83 36.45,12.95 38.4,12.95 38.46,12.9
LAN2_CT2_A-_V+ on BOTTOM: 37.95,10.19 37.74,9.98 37.74,7.9 37.72,7.87 37.06,7.87 37.03,7.9 37.03,10.49 36.11,11.42 31.81,11.42 31.27,10.87 28.45,10.87 28.4,10.92 28.4,12.9 28.45,12.95 37.69,12.95 37.95,12.7
LAN3_CT1_A+_V- on TOP: 54.61,11.68 54.03,11.1 54.03,9.4 53.9,9.27 52.35,9.27 50.98,10.64 48.67,10.64 48.56,10.74 48.56,12.85 48.67,12.95 54.48,12.95 54.61,12.83
LAN3_CT1_A+_V- on BOTTOM: 54.91,10.57 54.91,7.92 54.86,7.87 53.72,7.87 52.15,9.45 52.15,10.59 52.27,10.72 54.76,10.72
LAN3_CT2_A-_V+ on TOP: 58.65,11.61 57.96,10.92 57.96,9.47 57.91,9.42 56.62,9.42 56.52,9.53 56.52,12.83 56.64,12.95 58.6,12.95 58.65,12.9
LAN3_CT2_A-_V+ on BOTTOM: 58.14,10.19 57.94,9.98 57.94,7.9 57.91,7.87 57.25,7.87 57.23,7.9 57.23,10.49 56.41,11.3 51.89,11.3 51.46,10.87 48.64,10.87 48.59,10.92 48.59,12.9 48.64,12.95 57.89,12.95 58.14,12.7
LAN4_CT1_A+_V- on TOP: 74.8,11.43 74.42,11.05 74.42,9.4 74.3,9.27 73.03,9.27 71.65,10.64 68.86,10.64 68.76,10.74 68.76,12.85 68.86,12.95 74.65,12.95 74.8,12.8
LAN4_CT1_A+_V- on BOTTOM: 75.11,10.62 75.11,7.92 75.08,7.9 73.84,7.9 72.39,9.35 72.39,10.74 72.52,10.87 74.85,10.87
LAN4_CT2_A-_V+ on TOP: 78.84,11.61 78.16,10.92 78.16,9.47 78.11,9.42 76.81,9.42 76.71,9.53 76.71,12.83 76.83,12.95 78.79,12.95 78.84,12.9
LAN4_CT2_A-_V+ on BOTTOM: 78.33,10.19 78.13,9.98 78.13,7.9 78.11,7.87 77.44,7.87 77.42,7.9 77.42,10.49 76.56,11.35 72.14,11.35 71.65,10.87 68.83,10.87 68.78,10.92 68.78,12.88 68.86,12.95 78.08,12.95 78.33,12.7
LAN5_CT1_A+_V- on TOP: 95,11.43 94.61,11.05 94.61,9.4 94.49,9.27 93.22,9.27 91.85,10.64 89.05,10.64 88.95,10.74 88.95,12.85 89.04,12.94 94.91,12.94 95,12.85
LAN5_CT1_A+_V- on BOTTOM: 95.3,10.52 95.3,8 93.62,8 92.56,9.07 92.56,10.64 92.71,10.79 95.02,10.79
LAN5_CT2_A-_V+ on TOP: 99.03,11.61 98.35,10.92 98.35,9.47 98.3,9.42 97,9.42 96.9,9.53 96.9,12.83 97.03,12.95 98.98,12.95 99.03,12.9
LAN5_CT2_A-_V+ on BOTTOM: 98.53,10.19 98.32,9.98 98.32,7.9 98.3,7.87 97.64,7.87 97.61,7.9 97.61,10.21 96.6,11.23 92.2,11.23 91.85,10.87 89.03,10.87 88.98,10.92 88.98,12.88 89.04,12.94 98.29,12.94 98.53,12.7
LAN6_CT1_A+_V- on TOP: 115.19,11.43 114.81,11.05 114.81,9.4 114.68,9.27 113,9.27 111.63,10.64 109.25,10.64 109.14,10.74 109.14,12.88 109.21,12.94 115.1,12.94 115.19,12.85
LAN6_CT1_A+_V- on BOTTOM: 115.49,10.57 115.49,7.92 115.44,7.87 114.15,7.87 112.78,9.25 112.78,10.52 112.98,10.72 115.34,10.72
LAN6_CT2_A-_V+ on TOP: 119.23,11.61 118.54,10.92 118.54,9.47 118.49,9.42 117.2,9.42 117.09,9.53 117.09,12.83 117.22,12.95 119.18,12.95 119.23,12.9
LAN6_CT2_A-_V+ on BOTTOM: 118.72,10.19 118.52,9.98 118.52,7.9 118.49,7.87 117.83,7.87 117.81,7.9 117.81,10.49 116.92,11.38 112.55,11.38 112.04,10.87 109.22,10.87 109.17,10.92 109.17,12.9 109.21,12.94 118.48,12.94 118.72,12.7
LAN7_CT1_A+_V- on TOP: 135.38,11.43 135,11.05 135,9.4 134.87,9.27 133.6,9.27 132.23,10.64 129.44,10.64 129.34,10.74 129.34,12.83 129.46,12.95 135.28,12.95 135.38,12.85
LAN7_CT1_A+_V- on BOTTOM: 135.69,10.72 135.69,7.92 135.64,7.87 133.6,7.87 133.48,8 133.48,8.92 132.97,9.42 132.97,10.72 133.1,10.85 135.56,10.85
LAN7_CT2_A-_V+ on TOP: 139.42,11.61 138.73,10.92 138.73,9.47 138.68,9.42 137.39,9.42 137.29,9.53 137.29,12.83 137.41,12.95 139.37,12.95 139.42,12.9
LAN7_CT2_A-_V+ on BOTTOM: 138.91,10.19 138.71,9.98 138.71,7.9 138.68,7.87 138.02,7.87 138,7.9 138,10.49 137.05,11.44 132.8,11.44 132.23,10.87 129.41,10.87 129.36,10.92 129.36,12.83 129.48,12.94 138.67,12.94 138.91,12.7
LAN_GND on TOP (solid shape): 1.02,1.02 25.71,1.02 25.6,0.77 25.57,0.51 0.51,0.51 0.51,15.57 1.02,15.57
LAN_GND on TOP (solid shape): 159.49,0.51 147.17,0.51 147.15,0.74 147.07,0.96 147.1,1 147.16,1.02 158.98,1.02 158.98,56.33 159.2,56.87 158.98,57.42 158.98,57.53 159.49,57.53
LAN_GND on BOTTOM (solid shape): 149.63,61.47 149.63,59.82 149.5,59.69 145.19,59.69 145.06,59.82 145.06,61.47 145.31,61.72 149.38,61.72
LAN_GND on BOTTOM (solid shape): 1.02,1.02 25.71,1.02 25.6,0.77 25.57,0.51 0.51,0.51 0.51,15.85 1.02,15.85
LAN_GND on BOTTOM (solid shape): 159.49,0.51 147.17,0.51 147.15,0.74 147.07,0.96 147.1,1 147.16,1.02 158.98,1.02 158.98,56.33 159.49,56.33
LAN_GND on IN1 (solid shape): 1.02,1.02 25.71,1.02 25.6,0.77 25.57,0.51 0.51,0.51 0.51,15.85 1.02,15.85
LAN_GND on IN1 (solid shape): 159.49,0.51 147.17,0.51 147.14,0.77 147.03,1.02 158.98,1.02 158.98,56.33 159.49,56.33
LAN_GND on IN2 (solid shape): 1.02,1.02 25.71,1.02 25.6,0.77 25.57,0.51 0.51,0.51 0.51,15.84 1.02,15.84
LAN_GND on IN2 (solid shape): 159.49,0.51 147.17,0.51 147.14,0.77 147.03,1.02 158.98,1.02 158.98,56.01 159.49,56.01
LAN_GND on IN3 (solid shape): 1.02,1.02 25.71,1.02 25.6,0.77 25.57,0.51 0.51,0.51 0.51,15.88 1.02,15.88
LAN_GND on IN3 (solid shape): 159.49,0.51 147.17,0.51 147.14,0.77 147.03,1.02 158.98,1.02 158.98,56.26 159.49,56.26
LAN_GND on TOP: 145.16,56.52 147.07,56.52 147.19,56.39 147.19,54.86 147.07,54.74 145.16,54.74 145.03,54.86 145.03,56.39
LAN_GND on TOP: 4.14,15.75 4.14,5.66 4.39,5.41 10.59,5.41 12.5,7.32 26.09,7.32 27.41,8.64 31.62,8.64 32.94,7.32 47.14,7.32 48.46,8.64 51.66,8.64 52.98,7.32 67.54,7.32 68.86,8.64 73.08,8.64 74.4,7.32 87.73,7.32 89.05,8.64 94.39,8.64 95.71,7.32 107.92,7.32 109.25,8.64 112.42,8.64 113.74,7.32 128.12,7.32 129.44,8.64 132.36,8.64 133.68,7.32 148.16,7.32 148.26,7.21 148.26,3.68 148.08,3.51 1.47,3.51 1.22,3.76 1.22,15.67 1.42,15.88 4.01,15.88
LAN_GND on TOP: 151.69,56.13 151.82,56.26 153.16,56.26 153.29,56.13 153.29,43.18 153.16,43.05 150.88,43.05 150.75,43.18 150.75,44.32 151.69,45.26
LAN_GND on TOP: 145.29,51.44 146.94,51.44 147.07,51.31 147.07,49.66 146.94,49.53 145.29,49.53 145.16,49.66 145.16,51.31
LAN_GND on TOP: 145.31,61.72 149.38,61.72 149.63,61.47 149.63,59.82 149.5,59.69 145.19,59.69 145.06,59.82 145.06,61.47
LAN_GND on TOP: 145.41,46.35 147.7,46.35 147.83,46.23 147.83,44.96 147.7,44.83 145.41,44.83 145.29,44.96 145.29,46.23
LAN_GND on TOP: 25.4,12.9 27.53,12.9 27.64,12.8 27.64,11.25 27.43,11.05 25.58,11.05 25.35,11.28 25.35,12.85
LAN_GND on BOTTOM: 109.35,8.64 112.39,8.64 112.52,8.51 112.52,5.71 112.39,5.59 109.35,5.59 109.22,5.71 109.22,8.51
LAN_GND on BOTTOM: 4.14,5.54 4.01,5.41 1.47,5.41 1.35,5.54 1.35,15.8 1.42,15.88 4.01,15.88 4.14,15.75
LAN_GND on BOTTOM: 48.77,8.64 51.82,8.64 51.94,8.51 51.94,5.71 51.82,5.59 48.77,5.59 48.64,5.71 48.64,8.51
LAN_GND on BOTTOM: 89.15,8.64 92.2,8.64 92.33,8.51 92.33,5.71 92.2,5.59 89.15,5.59 89.03,5.71 89.03,8.51
LAN_GND on BOTTOM: 129.54,8.64 132.59,8.64 132.72,8.51 132.72,5.71 132.59,5.59 129.54,5.59 129.41,5.71 129.41,8.51
LAN_GND on BOTTOM: 28.57,8.64 31.11,8.64 31.27,8.48 31.27,5.74 31.11,5.59 28.57,5.59 28.45,5.71 28.45,8.51
LAN_GND on BOTTOM: 68.96,8.64 72.01,8.64 72.14,8.51 72.14,5.71 72.01,5.59 68.96,5.59 68.83,5.71 68.83,8.51
LAN_GND on GND1, VCC, GND2: 145.24,61.72 149.4,61.72 153.31,57.81 153.48,57.7 153.67,57.66 159.49,57.66 159.49,0.51 0.51,0.51 0.51,15.88 6.52,15.88 9.29,13.1 9.46,12.99 9.65,12.95 145.92,12.95 146.12,12.99 146.28,13.1 148.44,15.26 148.55,15.43 148.59,15.62 148.59,16.81 149.18,17.4 153.29,17.4 153.48,17.44 153.65,17.55 154.03,17.93 154.14,18.09 154.18,18.29 154.18,41.15 154.14,41.34 154.03,41.51 153.14,42.4 152.98,42.51 152.78,42.55 150.5,42.55 150.3,42.51 150.14,42.4 149.78,42.04 145.24,42.04 144.78,42.5 144.78,61.26
LAN_GND on IN1: 9.45,12.88 158.14,12.88 158.55,12.47 158.55,4.14 157.84,3.43 1.75,3.43 1.35,3.84 1.35,14.83 1.93,15.42 6.91,15.42 ; 1 cut-out
LAN_GND on IN1: 145.24,61.67 149.43,61.67 153.47,57.63 157.71,57.63 158.55,56.79 158.55,38.89 158.04,38.38 154.79,38.38 154.25,38.91 154.25,41.43 153.09,42.6 150.24,42.6 149.73,42.09 145.26,42.09 144.81,42.55 144.81,61.24
LAN_GND on IN2: 1.73,15.82 6.45,15.82 9.45,12.83 146.08,12.83 148.69,15.44 152.43,15.44 154.33,17.35 154.33,41.33 153.06,42.6 150.27,42.6 149.73,42.06 145.24,42.06 144.81,42.49 144.81,61.24 145.29,61.72 149.38,61.72 153.49,57.61 158.47,57.61 158.6,57.48 158.6,4.06 157.86,3.33 1.7,3.33 1.35,3.68 1.35,15.44
LAN_GND on IN3: 6.45,15.85 9.4,12.9 146.15,12.9 148.69,15.44 152.43,15.44 154.33,17.35 154.33,41.33 153.06,42.6 150.27,42.6 149.73,42.06 145.24,42.06 144.81,42.49 144.81,61.24 145.26,61.7 149.4,61.7 153.49,57.61 158.47,57.61 158.6,57.48 158.6,4.06 157.86,3.33 1.7,3.33 1.32,3.71 1.32,15.42 1.75,15.85
MCU2_VDD on BOTTOM: 143.03,80.14 144.81,80.14 144.93,80.01 144.93,77.85 144.81,77.72 143.03,77.72 142.9,77.85 142.9,80.01
MCU2_VDD on IN2: 135.31,80.77 150.65,80.77 151.54,79.88 151.54,66.55 148.29,63.3 148.29,63.27 147.93,62.92 144.81,62.92 143.61,61.72 143.61,60.91 143.28,60.58 121.95,60.58 115.98,66.55 115.98,75.56 119.39,78.98 133.52,78.98
MCU_VDD on IN3 (solid shape): 137.69,97.92 137.69,93.85 137.57,93.73 131.6,93.73 131.47,93.85 131.47,97.49 132.03,98.04 137.57,98.04
MCU_VDD on TOP: 131.93,97.92 138.33,97.92 138.46,97.79 138.46,93.6 138.33,93.47 131.6,93.47 131.47,93.6 131.47,97.46
MCU_VDD on BOTTOM: 131.6,93.73 131.47,93.85 131.47,97.43 131.95,97.92 137.57,97.92 137.69,97.79 137.69,93.85 137.57,93.73
MCU_VDD on BOTTOM: 145.44,80.14 146.96,80.14 147.09,80.01 147.09,77.85 146.96,77.72 145.44,77.72 145.31,77.85 145.31,80.01
MCU_VDD on IN1: 131.93,97.92 138.33,97.92 138.46,97.79 138.46,94.11 138.99,93.57 142.8,93.57 142.81,93.59 143.47,93.59 143.94,94.06 145.52,94.06 146.44,93.13 147.18,93.13 152.81,87.5 152.81,81.41 149.12,77.72 145.57,77.72 145.44,77.85 145.44,80.14 145.57,80.26 148.62,80.26 151.16,82.8 151.16,87.25 149.15,89.26 139.37,89.26 135.79,92.84 131.72,92.84 131.47,93.09 131.47,97.46
POE_56 on BOTTOM (solid shape): 26.7,116.28 28.52,116.28 28.52,100.53 27.89,99.9 13.16,99.9 12.9,100.15 12.9,105.23 13.03,105.36 20.27,105.36 21.36,106.45 21.36,116.28 21.62,116.54 26.44,116.54
POE_56 on IN2 (solid shape): 25.78,113.03 25.78,100.13 25.6,99.95 13.11,99.95 12.9,100.15 12.9,105.46 13.21,105.77 18.67,105.77 20.85,107.95 20.85,113.03 21.08,113.26 25.55,113.26
POE_56 on IN3 (solid shape): 25.78,113.03 25.78,100.13 25.6,99.95 14.22,99.95 13.72,100.46 13.72,105.38 14.1,105.77 18.67,105.77 20.85,107.95 20.85,113.03 21.08,113.26 25.55,113.26
POE_56 on TOP: 13.16,99.9 12.9,100.15 12.9,105.49 13.16,105.74 18.01,105.74 18.44,106.17 18.44,106.88 18.57,107.01 20.52,107.01 20.9,107.39 20.9,115.32 21.16,115.57 28.14,115.57 28.52,115.19 28.52,100.53 27.89,99.9
POE_56 on IN1: 25.78,113.03 25.78,100.13 25.6,99.95 13.11,99.95 12.9,100.15 12.9,105.46 13.21,105.77 18.67,105.77 20.85,107.95 20.85,113.03 21.08,113.26 25.55,113.26
POE_GATE on BOTTOM (solid shape): 17.86,94.31 17.86,89.48 17.73,89.36 12.52,89.36 12.27,89.1 12.27,85.42 12.14,85.29 7.37,85.29 5.79,86.87 5.79,94.18 6.05,94.44 17.73,94.44
POE_GATE on IN1 (solid shape): 17.86,94.31 17.86,89.48 17.73,89.36 12.52,89.36 12.27,89.1 12.27,85.42 12.14,85.29 6.3,85.29 5.79,85.8 5.79,94.18 6.05,94.44 17.73,94.44
POE_GATE on IN2 (solid shape): 17.86,94.31 17.86,89.48 17.73,89.36 12.52,89.36 12.27,89.1 12.27,85.42 12.14,85.29 6.83,85.29 6.68,85.45 6.68,94.13 6.99,94.44 17.73,94.44
POE_GATE on IN3 (solid shape): 17.86,94.31 17.86,89.48 17.73,89.36 12.52,89.36 12.27,89.1 12.27,85.42 12.14,85.29 6.83,85.29 6.68,85.45 6.68,94.13 6.99,94.44 17.73,94.44
POE_GATE on TOP: 17.73,94.44 17.86,94.31 17.86,89.48 17.73,89.36 12.52,89.36 12.27,89.1 12.27,85.42 12.14,85.29 7.44,85.29 6.93,84.79 4.27,84.79 4.14,84.91 4.14,87.58 5.79,89.23 5.79,94.18 6.05,94.44
POE_IN on TOP: 6.73,156.72 9.53,156.72 9.91,157.1 9.91,163.96 14.48,168.53 14.48,172.34 12.57,174.24 11.3,174.24 10.16,175.39 10.16,177.29 9.7,177.75 6.55,177.75 5.08,176.28 5.08,169.67 1.3,165.89 1.3,100.33 1.6,100.03 11.3,100.03 11.56,100.28 11.56,105.49 11.33,105.71 5.31,105.71 4.45,106.58 4.45,154.43
POE_IN on BOTTOM: 7.06,177.75 13.67,177.75 14.05,177.37 14.05,174.07 14.94,173.18 14.94,168.22 9.86,163.14 9.86,155.14 5.28,150.57 5.28,108.84 8.26,105.87 10.21,105.87 11.49,104.58 11.49,100.77 11.13,100.41 3.51,100.41 2.9,101.02 2.9,164.69 6.58,168.38 6.58,177.27
POE_IN on IN1: 2.74,105.89 9.86,105.89 10.03,105.71 10.03,100.2 9.83,100 2.67,100 2.36,100.3 2.36,105.51
POE_IN on IN2: 14.48,168.53 14.48,172.34 12.57,174.24 11.3,174.24 10.16,175.39 10.16,176.91 9.27,177.8 6.6,177.8 5.08,176.28 5.08,169.67 1.3,165.89 1.3,100.33 1.6,100.03 11.3,100.03 11.56,100.28 11.56,105.56 11.25,105.87 5.16,105.87 4.45,106.58 4.45,154.43 8.97,158.95 8.97,163.02
POE_IN on IN3: 6.73,156.72 9.78,156.72 10.06,157 10.06,164.11 14.48,168.53 14.48,172.34 12.57,174.24 11.3,174.24 10.16,175.39 10.16,177.55 9.91,177.8 5.33,177.8 5.08,177.55 5.08,169.67 1.3,165.89 1.3,100.46 1.73,100.03 11.3,100.03 11.56,100.28 11.56,105.56 11.25,105.87 5.16,105.87 4.45,106.58 4.45,154.43
POE_IN_MOS on TOP: 9.98,99.52 10.11,99.39 10.11,98.12 10.36,97.87 11.25,97.87 11.38,97.74 11.38,95.45 11.25,95.33 7.95,95.33 7.82,95.45 7.82,96.72 7.7,96.85 5.41,96.85 5.16,96.6 5.16,94.44 4.65,93.93 1.6,93.93 1.35,94.18 1.35,99.26 1.6,99.52
POE_OUT1A on TOP: 1.85,55.7 3.89,55.7 4.01,55.58 4.01,53.67 3.89,53.54 1.85,53.54 1.73,53.67 1.73,55.58
POE_OUT1A on BOTTOM: 1.6,55.7 4.39,55.7 4.65,55.45 4.65,48.97 4.52,48.84 1.6,48.84 1.47,48.97 1.47,55.58
POE_OUT1B on TOP: 11.51,55.42 11.51,53.67 11.38,53.54 9.35,53.54 9.22,53.67 9.22,55.4 9.42,55.6 11.33,55.6
POE_OUT1B on TOP: 9.65,41.25 11.68,41.25 11.86,41.07 11.86,39.45 11.66,39.24 9.65,39.24 9.45,39.45 9.45,41.05
POE_OUT1B on BOTTOM: 12.14,55.32 12.14,48.97 12.01,48.84 9.09,48.84 8.97,48.97 8.97,55.32 9.25,55.6 11.86,55.6
POE_OUT1B on IN2: 8.59,55.68 10.08,55.68 10.26,55.5 10.26,52.91 9.98,52.63 8.59,52.63 8.46,52.76 8.46,55.55
POE_OUT1B on IN2: 9.53,41.3 11.76,41.3 11.91,41.15 11.91,39.52 11.66,39.27 9.53,39.27 9.32,39.47 9.32,41.1
POE_OUT2 on TOP: 2.62,66.75 2.49,66.88 2.49,69.55 2.62,69.67 4.01,69.67 4.14,69.55 4.14,66.88 4.01,66.75
POE_OUT2 on TOP: 32.77,15.75 34.42,15.75 34.54,15.62 34.54,14.1 34.42,13.97 32.77,13.97 32.64,14.1 32.64,15.62
POE_OUT2 on BOTTOM: 4.65,62.18 4.52,62.05 1.6,62.05 1.47,62.18 1.47,69.55 1.6,69.67 4.52,69.67 4.65,69.55
POE_OUT2 on IN2: 34.32,16 34.44,15.88 34.44,14.73 34.32,14.61 31.52,14.61 31.39,14.73 31.39,15.88 31.52,16
POE_OUT2 on IN2: 2.64,69.75 4.29,69.75 4.42,69.62 4.42,67.72 4.29,67.59 2.51,67.59 2.39,67.72 2.39,69.49
POE_OUT3 on TOP: 52.96,15.75 54.61,15.75 54.74,15.62 54.74,14.1 54.61,13.97 52.96,13.97 52.83,14.1 52.83,15.62
POE_OUT3 on TOP: 9.35,68.91 11.38,68.91 11.51,68.78 11.51,66.88 11.38,66.75 9.35,66.75 9.22,66.88 9.22,68.78
POE_OUT3 on BOTTOM: 9.09,68.91 11.89,68.91 12.14,68.66 12.14,62.18 12.01,62.05 9.09,62.05 8.97,62.18 8.97,68.78
POE_OUT3 on IN2: 8.89,68.81 11.05,68.81 11.18,68.68 11.18,66.14 11.05,66.01 8.89,66.01 8.76,66.14 8.76,68.68
POE_OUT3 on IN2: 52.6,16 54.25,16 54.38,15.88 54.38,14.48 54.25,14.35 52.6,14.35 52.48,14.48 52.48,15.88
POE_OUT4 on TOP: 16.84,55.7 18.87,55.7 19,55.58 19,53.67 18.87,53.54 16.84,53.54 16.71,53.67 16.71,55.58
POE_OUT4 on TOP: 73.15,15.75 74.8,15.75 74.93,15.62 74.93,14.1 74.8,13.97 73.15,13.97 73.03,14.1 73.03,15.62
POE_OUT4 on BOTTOM: 16.59,55.7 19.38,55.7 19.63,55.45 19.63,48.97 19.51,48.84 16.59,48.84 16.46,48.97 16.46,55.58
POE_OUT4 on IN2: 72.16,16.13 74.57,16.13 74.7,16 74.7,14.61 74.57,14.48 72.16,14.48 72.03,14.61 72.03,16
POE_OUT4 on IN2: 16.66,55.75 18.44,55.75 18.57,55.63 18.57,52.98 18.29,52.7 16.66,52.7 16.54,52.83 16.54,55.63
POE_OUT5 on TOP: 93.34,15.75 95,15.75 95.12,15.62 95.12,14.1 95,13.97 93.34,13.97 93.22,14.1 93.22,15.62
POE_OUT5 on TOP: 26.37,55.42 26.37,53.67 26.24,53.54 24.21,53.54 24.08,53.67 24.08,55.42 24.26,55.6 26.19,55.6
POE_OUT5 on BOTTOM: 23.95,55.7 26.39,55.7 26.62,55.47 26.62,51.79 27,51.41 27,48.97 26.87,48.84 23.95,48.84 23.83,48.97 23.83,55.58
POE_OUT5 on IN2: 23.62,55.47 25.53,55.47 25.65,55.35 25.65,53.44 25.4,53.19 23.62,53.19 23.37,53.44 23.37,55.22
POE_OUT5 on IN2: 92.1,16 94.64,16 94.77,15.88 94.77,14.61 94.64,14.48 91.97,14.48 91.85,14.61 91.85,15.75
POE_OUT6 on TOP: 113.54,15.75 115.19,15.75 115.32,15.62 115.32,14.1 115.19,13.97 113.54,13.97 113.41,14.1 113.41,15.62
POE_OUT6 on TOP: 16.84,68.91 18.87,68.91 19,68.78 19,66.88 18.87,66.75 16.84,66.75 16.71,66.88 16.71,68.78
POE_OUT6 on BOTTOM: 16.59,68.91 19.38,68.91 19.63,68.66 19.63,62.18 19.51,62.05 16.59,62.05 16.46,62.18 16.46,68.78
POE_OUT6 on IN2: 16.22,69.04 18.38,69.04 18.5,68.91 18.5,66.37 18.38,66.24 16.22,66.24 16.09,66.37 16.09,68.91
POE_OUT6 on IN2: 114.96,15.88 115.09,15.75 115.09,14.48 114.96,14.35 111.81,14.35 111.63,14.53 111.63,15.65 111.86,15.88
POE_OUT7 on TOP: 24.33,68.91 26.37,68.91 26.49,68.78 26.49,66.88 26.37,66.75 24.33,66.75 24.21,66.88 24.21,68.78
POE_OUT7 on TOP: 133.73,15.75 135.38,15.75 135.51,15.62 135.51,14.1 135.38,13.97 133.73,13.97 133.6,14.1 133.6,15.62
POE_OUT7 on BOTTOM: 24.08,68.91 26.87,68.91 27.13,68.66 27.13,62.18 27,62.05 24.08,62.05 23.95,62.18 23.95,68.78
POE_OUT7 on IN2: 133.12,16 135.03,16 135.15,15.88 135.15,14.86 135.03,14.73 132.99,14.73 132.87,14.86 132.87,15.75
POE_OUT7 on IN2: 24.05,68.66 25.83,68.66 25.96,68.53 25.96,66.5 25.7,66.24 24.05,66.24 23.8,66.5 23.8,68.4
POE_VCC on BOTTOM (solid shape): 19.63,88.72 19.63,83.77 19.51,83.64 13.03,83.64 12.9,83.77 12.9,88.72 13.03,88.85 19.51,88.85
POE_VCC on IN1 (solid shape): 19.63,88.72 19.63,83.77 19.51,83.64 13.03,83.64 12.9,83.77 12.9,88.72 13.03,88.85 19.51,88.85
POE_VCC on IN2 (solid shape): 19.63,88.72 19.63,83.77 19.51,83.64 13.03,83.64 12.9,83.77 12.9,88.72 13.03,88.85 19.51,88.85
POE_VCC on IN3 (solid shape): 19.63,88.72 19.63,84.71 19.25,84.33 13.28,84.33 12.9,84.71 12.9,88.72 13.03,88.85 19.51,88.85
POE_VCC on TOP: 13.03,88.85 19.51,88.85 19.63,88.72 19.63,83.77 19.51,83.64 13.03,83.64 12.9,83.77 12.9,88.72
POE_VCC on TOP: 139.7,14.1 139.57,13.97 137.67,13.97 137.54,14.1 137.54,15.62 137.67,15.75 139.57,15.75 139.7,15.62
POE_VCC on TOP: 38.73,14.1 38.61,13.97 36.7,13.97 36.58,14.1 36.58,15.62 36.7,15.75 38.61,15.75 38.73,15.62
POE_VCC on TOP: 99.31,14.1 99.19,13.97 97.28,13.97 97.16,14.1 97.16,15.62 97.28,15.75 99.19,15.75 99.31,15.62
POE_VCC on TOP: 58.93,14.1 58.8,13.97 56.9,13.97 56.77,14.1 56.77,15.62 56.9,15.75 58.8,15.75 58.93,15.62
POE_VCC on TOP: 79.12,14.1 78.99,13.97 77.09,13.97 76.96,14.1 76.96,15.62 77.09,15.75 78.99,15.75 79.12,15.62
POE_VCC on TOP: 119.51,14.1 119.38,13.97 117.47,13.97 117.35,14.1 117.35,15.62 117.47,15.75 119.38,15.75 119.51,15.62
POE_VCC on TOP: 13.41,13.79 19.76,13.79 19.89,13.92 19.89,16.08 19.76,16.21 13.41,16.21 13.28,16.08 13.28,13.92
POE_VCC on BOTTOM: 20.4,62.05 20.27,62.18 20.27,67.01 20.4,67.13 23.32,67.13 23.44,67.01 23.44,62.18 23.32,62.05
POE_VCC on BOTTOM: 12.9,62.05 12.78,62.18 12.78,67.01 12.9,67.13 15.82,67.13 15.95,67.01 15.95,62.18 15.82,62.05
POE_VCC on BOTTOM: 5.41,48.84 5.28,48.97 5.28,53.62 5.59,53.92 8.05,53.92 8.26,53.72 8.26,49.1 8,48.84
POE_VCC on BOTTOM: 5.41,62.05 5.28,62.18 5.28,67.01 5.41,67.13 8.33,67.13 8.46,67.01 8.46,62.18 8.33,62.05
POE_VCC on BOTTOM: 27.89,62.05 27.76,62.18 27.76,67.01 27.89,67.13 30.81,67.13 30.94,67.01 30.94,62.18 30.81,62.05
POE_VCC on BOTTOM: 20.4,48.84 20.27,48.97 20.27,53.8 20.4,53.92 23.04,53.92 23.24,53.72 23.24,48.97 23.11,48.84
POE_VCC on BOTTOM: 12.01,72.47 13.03,72.47 13.16,72.34 13.16,70.31 13.03,70.18 12.01,70.18 11.89,70.31 11.89,72.34
POE_VCC on BOTTOM: 27.76,48.84 27.64,48.97 27.64,51.36 27.99,51.71 27.99,53.77 28.14,53.92 30.68,53.92 30.81,53.8 30.81,48.97 30.68,48.84
POE_VCC on BOTTOM: 12.9,48.84 12.78,48.97 12.78,53.8 12.9,53.92 15.54,53.92 15.75,53.72 15.75,48.97 15.62,48.84
POE_VCC on VCC: outline of 92 points within 0.51,13.97 139.45,88.77 ; 1 cut-out
POE_VCC_MOS on TOP: 14.3,95.33 17.98,95.33 19.51,93.8 22.81,93.8 22.94,93.93 22.94,97.74 22.81,97.87 16.71,97.87 16.46,98.12 16.46,99.39 16.33,99.52 13.03,99.52 12.9,99.39 12.9,97.23 13.03,97.1 13.92,97.1 14.17,96.85 14.17,95.45
PSE_D1 on TOP: 7.52,55.42 7.52,48.13 7.34,47.96 2.82,47.96 2.65,48.12 2.65,52.95 2.74,53.04 4.52,53.04 4.78,53.29 4.78,55.47 4.9,55.6 7.34,55.6
PSE_D2 on TOP: 12.4,55.7 14.68,55.7 14.81,55.58 14.81,48.08 14.68,47.96 10.11,47.96 9.98,48.08 9.98,52.78 10.24,53.04 12.01,53.04 12.27,53.29 12.27,55.58
PSE_D3 on TOP: 4.9,68.91 7.19,68.91 7.32,68.78 7.32,61.29 7.19,61.16 2.62,61.16 2.49,61.29 2.49,65.99 2.74,66.24 4.52,66.24 4.78,66.5 4.78,68.78
PSE_D4 on TOP: 12.4,68.91 14.68,68.91 14.81,68.78 14.81,61.29 14.68,61.16 10.11,61.16 9.98,61.29 9.98,65.99 10.24,66.24 12.01,66.24 12.27,66.5 12.27,68.78
PSE_D5 on TOP: 22.3,55.32 22.3,48.08 22.17,47.96 17.6,47.96 17.48,48.08 17.48,52.78 17.73,53.04 19.51,53.04 19.76,53.29 19.76,55.37 19.99,55.6 22.02,55.6
PSE_D6 on TOP: 29.67,55.4 29.67,48.08 29.54,47.96 24.97,47.96 24.84,48.08 24.84,52.78 25.1,53.04 26.87,53.04 27.13,53.29 27.13,55.45 27.28,55.6 29.46,55.6
PSE_D7 on TOP: 19.89,68.91 22.17,68.91 22.3,68.78 22.3,61.29 22.17,61.16 17.6,61.16 17.48,61.29 17.48,65.99 17.73,66.24 19.51,66.24 19.76,66.5 19.76,68.78
PSE_D8 on TOP: 27.38,68.91 29.67,68.91 29.79,68.78 29.79,61.29 29.67,61.16 25.1,61.16 24.97,61.29 24.97,65.99 25.22,66.24 27,66.24 27.25,66.5 27.25,68.78
PSE_SEN1 on TOP: 2.95,47.19 6.02,47.19 6.05,47.17 6.05,43.48 5.89,43.33 2.9,43.33 2.79,43.43 2.79,47.04
PSE_SEN2 on TOP: 10.24,47.19 13.28,47.19 13.41,47.07 13.41,43.41 13.31,43.31 11.28,43.31 11.18,43.41 11.18,44.83 10.11,45.9 10.11,47.07
PSE_SEN3 on TOP: 2.74,60.4 5.79,60.4 5.92,60.27 5.92,56.69 5.77,56.54 2.77,56.54 2.62,56.69 2.62,60.27
PSE_SEN4 on TOP: 10.24,60.4 13.28,60.4 13.41,60.27 13.41,56.62 13.34,56.54 11.51,56.54 11.38,56.67 11.38,57.89 10.11,59.16 10.11,60.27
PSE_SEN5 on TOP: 17.73,47.19 20.78,47.19 20.9,47.07 20.9,43.38 20.83,43.31 17.78,43.31 17.6,43.48 17.6,47.07
PSE_SEN6 on TOP: 25.1,47.19 28.14,47.19 28.27,47.07 28.27,45.36 27.99,45.09 27.99,43.41 27.91,43.33 26.14,43.33 26.04,43.43 26.04,45.09 25.53,45.59 25.27,45.59 24.97,45.9 24.97,47.07
PSE_SEN7 on TOP: 17.73,60.4 20.78,60.4 20.9,60.27 20.9,56.64 20.78,56.52 17.73,56.52 17.6,56.64 17.6,60.27
PSE_SEN8 on TOP: 25.22,60.4 28.27,60.4 28.4,60.27 28.4,56.62 28.3,56.52 26.42,56.52 26.24,56.69 26.24,58.01 25.1,59.16 25.1,60.27
RX_PAVDD_A on BOTTOM: 95.66,91.19 99.97,91.19 100.23,90.93 101.37,90.93 101.5,90.81 101.5,89.92 101.37,89.79 99.59,89.79 99.34,89.53 94.77,89.53 94.64,89.66 94.64,90.81 94.77,90.93 95.4,90.93
TX_AVDD_A on BOTTOM: 94.01,82.04 96.55,82.04 97.05,82.55 98.32,82.55 99.21,83.44 100.23,83.44 100.48,83.69 101.24,83.69 101.37,83.57 101.37,81.28 101.24,81.15 97.82,81.15 97.69,81.03 97.05,81.03 96.98,80.95 96.49,80.95 96.42,81.03 94.89,81.03 94.77,80.9 94.01,80.9 93.88,81.03 93.88,81.92
USB_GND on TOP: 77.47,198.5 78.87,198.5 78.99,198.37 78.99,197.1 79.76,196.34 80.9,196.34 84.71,192.53 84.71,183.39 84.58,183.26 82.3,183.26 82.17,183.39 82.17,185.42 82.55,185.8 82.55,190.5 82.3,190.75 80.39,190.75 77.34,193.8 77.34,198.37
USB_GND on BOTTOM: 82.68,185.42 84.07,185.42 84.2,185.29 84.2,183.13 84.07,183.01 82.68,183.01 82.55,183.13 82.55,185.29
VP10_HUB on TOP: 82.58,60.12 82.58,59.41 82.52,59.36 81.86,59.36 81.79,59.44 81.79,60.38 81.74,60.43 81.74,60.63 81.81,60.71 81.81,61.26 81.92,61.37 82.55,61.37 82.6,61.32 82.6,60.86 82.75,60.71 82.75,60.3
VP10_HUB on BOTTOM: 78.64,72.72 84.02,72.72 84.79,71.96 88.98,71.96 89.36,71.58 89.36,62.18 87.83,60.66 86.56,60.66 86.06,60.15 81.48,60.15 80.34,61.29 77.04,61.29 76.02,62.31 76.02,66.34 76.61,66.93 77.24,66.93 78.38,68.07 78.38,72.47
N16705548 on TOP: 41.53,161.8 47.62,161.8 47.88,161.54 47.88,152.98 46.41,151.51 38.1,151.51 37.85,151.76 37.85,157.1 37.97,157.23 40.89,157.23 41.4,157.73 41.4,161.67
N16715221 on BOTTOM (solid shape): 18.31,126.34 18.31,120.29 18.03,120.02 12.09,120.02 11.84,120.27 11.84,120.78 12.22,121.16 12.22,124.33 12.47,124.59 12.99,124.59 13.12,124.71 13.12,126.48 13.26,126.62 18.03,126.62
N16715221 on IN2 (solid shape): 18.16,126.49 18.16,120.14 18.03,120.02 11.05,120.02 10.79,120.27 10.79,124.33 10.92,124.46 12.32,124.46 12.7,124.84 12.7,126.06 13.26,126.62 18.03,126.62
N16715221 on IN3 (solid shape): 18.16,126.49 18.16,120.14 18.03,120.02 12.09,120.02 11.86,120.24 11.86,123.88 13.23,125.25 13.23,126.21 13.36,126.34 13.64,126.34 13.92,126.62 18.03,126.62
N16715221 on TOP: 18.16,120.14 18.03,120.02 11.05,120.02 10.79,120.27 10.79,124.33 10.92,124.46 12.32,124.46 12.7,124.84 12.7,126.06 13.26,126.62 18.03,126.62 18.16,126.49
N16715221 on IN1: 18.16,125.6 17.53,124.97 17.53,120.29 17.25,120.02 12.09,120.02 11.86,120.24 11.86,123.88 12.95,124.97 12.95,126.31 13.26,126.62 18.03,126.62 18.16,126.49
N16715269 on BOTTOM (solid shape): 18.31,135.13 18.31,127.51 18.06,127.25 13.87,127.25 12.14,128.98 12.14,135.13 12.4,135.38 18.06,135.38
N16715269 on IN1 (solid shape): 18.54,135.25 18.54,127.76 18.03,127.25 13.87,127.25 12.14,128.98 12.14,135.13 12.4,135.38 18.41,135.38
N16715269 on IN2 (solid shape): 18.54,135.25 18.54,127.76 18.03,127.25 13.87,127.25 12.14,128.98 12.14,135.13 12.4,135.38 18.41,135.38
N16715269 on IN3 (solid shape): 18.54,135.25 18.54,127.76 18.03,127.25 13.87,127.25 12.14,128.98 12.14,135.13 12.4,135.38 18.41,135.38
N16715269 on TOP: 18.54,127.76 18.03,127.25 13.87,127.25 12.14,128.98 12.14,135.13 12.4,135.38 18.41,135.38 18.54,135.25
N16715396 on IN1 (solid shape): 34.54,135.28 34.54,119.51 34.37,119.33 28.55,119.33 28.32,119.56 28.32,124.79 29.08,125.55 29.08,127.56 28.63,128.02 22.48,128.02 22.35,128.14 22.35,135.38 22.68,135.71 34.11,135.71
N16715396 on IN2 (solid shape): 34.54,135.28 34.54,119.51 34.37,119.33 27.89,119.33 27.43,119.79 27.43,124.33 27.56,124.46 29.34,124.46 29.46,124.59 29.46,127.76 29.21,128.02 22.48,128.02 22.35,128.14 22.35,135.38 22.68,135.71 34.11,135.71
N16715396 on IN3 (solid shape): 34.54,135.28 34.54,119.51 34.37,119.33 27.89,119.33 27.43,119.79 27.43,124.33 27.56,124.46 29.34,124.46 29.46,124.59 29.46,127.76 29.21,128.02 22.48,128.02 22.35,128.14 22.35,135.38 22.68,135.71 34.11,135.71
N16715396 on TOP: 34.54,119.51 34.37,119.33 27.89,119.33 27.43,119.79 27.43,124.33 27.56,124.46 29.34,124.46 29.46,124.59 29.46,127.76 29.21,128.02 22.48,128.02 22.35,128.14 22.35,135.38 22.68,135.71 34.11,135.71 34.54,135.28
N16715396 on BOTTOM: 34.62,119.58 34.37,119.33 30.12,119.33 29.78,119.67 29.78,128.36 29.41,128.73 27.64,128.73 27.46,128.91 27.46,130.56 27.08,130.94 23.39,130.94 23.14,131.19 23.14,135.33 23.52,135.71 34.24,135.71 34.62,135.33
N16716334 on IN1 (solid shape): 26.75,127.23 26.75,126.03 26.54,125.83 26.54,119.51 26.37,119.33 21.92,119.33 21.72,119.53 21.72,127.25 21.84,127.38 26.59,127.38
N16716334 on IN2 (solid shape): 26.75,127.23 26.75,126.03 26.54,125.83 26.54,119.51 26.37,119.33 21.92,119.33 21.72,119.53 21.72,127.25 21.84,127.38 26.59,127.38
N16716334 on IN3 (solid shape): 26.54,127.13 26.54,119.51 26.37,119.33 21.92,119.33 21.72,119.53 21.72,127.25 21.84,127.38 26.29,127.38
N16716334 on TOP: 26.54,119.63 26.34,119.43 21.92,119.43 21.72,119.63 21.72,127.25 21.84,127.38 26.29,127.38 26.54,127.13
N16716334 on BOTTOM: 22.63,130.38 26.49,130.38 26.82,130.05 26.82,125.86 28.6,124.08 28.6,118.24 28.35,117.98 26.95,117.98 26.14,117.17 22.94,117.17 22.68,117.42 22.68,124.16 22.25,124.59 22.25,130
N16718141 on BOTTOM (solid shape): 21.41,133.05 21.41,131.27 21.29,131.14 18.87,131.14 18.75,131.27 18.75,133.05 18.87,133.17 21.29,133.17
N17477531 on TOP: 40.18,11.48 41.55,11.48 41.66,11.38 41.66,9.5 41.58,9.42 40.18,9.42 40.06,9.55 40.06,11.35
N17477531 on BOTTOM: 40.87,10.31 40.72,10.16 40.72,7.9 40.69,7.87 40.08,7.87 40.06,7.9 40.06,11.35 40.18,11.48 41.55,11.48 41.66,11.38 41.66,10.39 41.58,10.31
N17477559 on TOP: 44.45,11.51 45.54,11.51 45.62,11.43 45.62,9.42 45.54,9.35 44.48,9.35 44.37,9.45 44.37,11.43
N17477559 on BOTTOM: 45.64,11.43 45.64,10.34 45.57,10.26 43.81,10.26 43.71,10.16 43.71,7.9 43.69,7.87 43.08,7.87 43.05,7.9 43.05,11.38 43.18,11.51 45.57,11.51
N17486352 on TOP: 60.38,11.48 61.75,11.48 61.85,11.38 61.85,9.5 61.77,9.42 60.38,9.42 60.25,9.55 60.25,11.35
N17486352 on BOTTOM: 61.14,10.39 60.91,10.16 60.91,7.9 60.88,7.87 60.27,7.87 60.25,7.9 60.25,11.35 60.38,11.48 61.75,11.48 61.85,11.38 61.85,10.44 61.8,10.39
N17486475 on TOP: 64.64,11.51 65.74,11.51 65.81,11.43 65.81,9.42 65.74,9.35 64.67,9.35 64.57,9.45 64.57,11.43
N17486475 on BOTTOM: 65.84,11.43 65.84,10.34 65.76,10.26 64.01,10.26 63.91,10.16 63.91,7.9 63.88,7.87 63.27,7.87 63.25,7.9 63.25,11.38 63.37,11.51 65.76,11.51
N17487128 on TOP: 80.57,11.48 81.94,11.48 82.04,11.38 82.04,9.5 81.97,9.42 80.57,9.42 80.44,9.55 80.44,11.35
N17487128 on BOTTOM: 81.1,10.08 81.1,7.9 81.08,7.87 80.47,7.87 80.44,7.9 80.44,11.35 80.57,11.48 81.94,11.48 82.04,11.38 82.04,10.31 81.94,10.21 81.23,10.21
N17487156 on TOP: 84.84,11.51 85.93,11.51 86,11.43 86,9.42 85.93,9.35 84.86,9.35 84.76,9.45 84.76,11.43
N17487156 on BOTTOM: 86.03,11.43 86.03,10.34 85.95,10.26 84.2,10.26 84.1,10.16 84.1,7.9 84.07,7.87 83.46,7.87 83.44,7.9 83.44,11.38 83.57,11.51 85.95,11.51
N17488314 on TOP: 100.76,11.48 102.13,11.48 102.23,11.38 102.23,9.5 102.16,9.42 100.76,9.42 100.63,9.55 100.63,11.35
N17488314 on BOTTOM: 101.45,10.31 101.3,10.16 101.3,7.9 101.27,7.87 100.66,7.87 100.63,7.9 100.63,11.35 100.76,11.48 102.13,11.48 102.23,11.38 102.23,10.39 102.16,10.31
N17488336 on TOP: 105.03,11.51 106.12,11.51 106.2,11.43 106.2,9.42 106.12,9.35 105.05,9.35 104.95,9.45 104.95,11.43
N17488336 on BOTTOM: 106.22,11.43 106.22,10.34 106.15,10.26 104.39,10.26 104.29,10.16 104.29,7.9 104.27,7.87 103.66,7.87 103.63,7.9 103.63,11.38 103.76,11.51 106.15,11.51
N17488976 on TOP: 120.95,11.48 122.33,11.48 122.43,11.38 122.43,9.5 122.35,9.42 120.95,9.42 120.83,9.55 120.83,11.35
N17488976 on BOTTOM: 121.62,10.29 121.49,10.16 121.49,7.9 121.46,7.87 120.85,7.87 120.83,7.9 120.83,11.35 120.95,11.48 122.33,11.48 122.43,11.38 122.43,10.36 122.35,10.29
N17489028 on TOP: 125.22,11.51 126.31,11.51 126.39,11.43 126.39,9.42 126.31,9.35 125.25,9.35 125.15,9.45 125.15,11.43
N17489028 on BOTTOM: 126.42,11.43 126.42,10.34 126.34,10.26 124.59,10.26 124.49,10.16 124.49,7.9 124.46,7.87 123.85,7.87 123.83,7.9 123.83,11.38 123.95,11.51 126.34,11.51
N17489888 on TOP: 145.41,11.51 146.51,11.51 146.58,11.43 146.58,9.42 146.51,9.35 145.44,9.35 145.34,9.45 145.34,11.43
N17489888 on BOTTOM: 146.61,11.43 146.61,10.34 146.53,10.26 144.78,10.26 144.68,10.16 144.68,7.9 144.65,7.87 144.04,7.87 144.02,7.9 144.02,11.38 144.15,11.51 146.53,11.51
N17489893 on TOP: 141.15,11.48 142.52,11.48 142.62,11.38 142.62,9.5 142.54,9.42 141.15,9.42 141.02,9.55 141.02,11.35
N17489893 on BOTTOM: 141.68,9.91 141.68,7.9 141.66,7.87 141.05,7.87 141.02,7.9 141.02,11.35 141.15,11.48 142.14,11.48 142.15,11.47 142.58,11.47 142.62,11.43 142.62,10.29 142.49,10.16 141.94,10.16
N17490600 on TOP: 145.16,58.55 149.61,58.55 149.73,58.42 149.73,57.28 149.61,57.15 145.16,57.15 145.03,57.28 145.03,58.42
N17490600 on BOTTOM: 148.74,54.23 149.1,53.87 151.1,53.87 151.13,53.85 151.13,53.24 151.1,53.21 148.21,53.21 147.19,54.23 147.19,58.42 147.32,58.55 148.59,58.55 148.74,58.39
N17490605 on TOP: 145.16,52.32 145.16,53.59 145.29,53.72 149.73,53.72 149.86,53.59 149.86,52.7 149.61,52.45 147.83,52.45 147.57,52.2 145.29,52.2
N17490605 on BOTTOM: 151.1,50.88 151.13,50.85 151.13,50.24 151.1,50.22 147.14,50.22 146.43,50.93 146.43,53.09 146.69,53.34 147.45,53.34 148.46,52.32 148.46,51.31 148.89,50.88
N17490610 on TOP: 149.73,46.84 149.61,46.71 145.41,46.71 145.29,46.84 145.29,48.26 145.41,48.39 147.32,48.39 147.7,48.01 149.61,48.01 149.73,47.88
N17490610 on BOTTOM: 151.1,47.9 151.13,47.88 151.13,47.22 151.1,47.19 148.51,47.19 148.03,46.71 146.84,46.71 146.71,46.84 146.71,48.26 146.84,48.39 147.88,48.39 148.36,47.9
N17490615 on TOP: 149.73,43.94 149.73,42.16 149.61,42.04 145.41,42.04 145.29,42.16 145.29,43.81 145.54,44.07 149.61,44.07
N17490615 on BOTTOM: 147.98,44.88 151.23,44.88 151.41,44.7 151.41,42.8 151.28,42.67 147.35,42.67 147.22,42.8 147.22,44.12
N17524230 on TOP: 105.49,51.1 105.49,50.75 105.36,50.62 103.73,50.62 103.61,50.75 103.61,52.6 103.91,52.91 106.73,52.91 107.82,51.82 108.51,51.82 108.64,51.69 108.64,50.39 108.53,50.29 107.37,50.29 107.01,50.65 107.01,51.1 106.53,51.59 105.97,51.59
N18797950 on TOP: 22.86,182.25 22.99,182.12 22.99,179.32 24.38,177.93 24.38,173.61 24,173.23 15.06,173.23 14.48,173.81 14.48,181.86 14.86,182.25
N18797950 on BOTTOM: 20.22,178.69 19.96,178.44 19.96,177.04 20.09,176.91 21.49,176.91 21.62,176.78 21.62,173.35 21.11,172.85 15.88,172.85 14.48,174.24 14.48,182.09 16.41,184.02 16.41,185.93 17.17,186.69 22.5,186.69 22.63,186.56 22.63,181.23 22.12,180.72 20.47,180.72 20.22,180.47 ; 1 cut-out
N18797950 on IN3: 14.86,182.25 21.59,182.25 21.97,181.86 21.97,173.48 21.72,173.23 15.11,173.23 14.25,174.09 14.25,181.64
N18798086 on TOP: 22.48,184.28 22.23,184.02 17.27,184.02 17.02,184.28 17.02,188.98 17.42,189.38 22.07,189.38 22.48,188.98
N18799364 on TOP: 1.4,182.5 6.99,182.5 7.11,182.37 7.11,179.58 4.19,176.66 1.4,176.66 1.27,176.78 1.27,182.37
N18799364 on BOTTOM: 1.52,181.99 4.57,181.99 4.7,181.86 4.7,176.78 4.57,176.66 1.4,176.66 1.27,176.78 1.27,181.74
N59691951 on TOP: 54.61,10.97 55.75,10.97 55.83,10.9 55.83,7.85 55.78,7.8 54.64,7.8 54.56,7.87 54.56,10.92
N59698211 on TOP: 46.18,11.02 47.52,11.02 47.65,10.9 47.65,8.33 47.12,7.8 46.15,7.8 46.1,7.85 46.1,10.95
N59698213 on TOP: 42.37,11.07 43.41,11.07 43.51,10.97 43.51,7.85 43.43,7.77 42.34,7.77 42.24,7.87 42.24,10.95
N59698215 on TOP: 38.4,10.95 39.37,10.95 39.47,10.85 39.47,7.87 39.37,7.77 38.38,7.77 38.3,7.85 38.3,10.85
N59698217 on TOP: 34.39,10.97 35.76,10.97 35.84,10.9 35.84,7.87 35.76,7.8 34.39,7.8 34.29,7.9 34.29,10.87
N198715748 on BOTTOM: 138.96,100.33 140.49,100.33 140.61,100.2 140.61,99.19 142.14,97.66 142.14,96.93 142.62,96.44 144.42,96.44 144.45,96.42 144.45,96.14 144.4,96.09 143.64,96.09 142.85,95.3 142.85,93.98 142.65,93.78 138.96,93.78 138.84,93.9 138.84,100.2
N236903803 on IN3 (solid shape): 144.81,87.88 144.81,83.69 144.68,83.57 142.01,83.57 141,84.58 138.07,84.58 137.82,84.84 135.79,84.84 135.15,85.47 132.99,85.47 132.87,85.6 132.87,85.85 132.99,85.98 137.82,85.98 139.34,87.5 139.34,87.76 139.6,88.01 144.68,88.01
N236903803 on TOP: 139.6,88.01 144.68,88.01 144.81,87.88 144.81,84.71 144.68,84.58 138.07,84.58 137.82,84.84 135.66,84.84 135.53,84.96 135.53,85.34 135.66,85.47 137.31,85.47 139.34,87.5 139.34,87.76
N236903803 on BOTTOM: 132.99,85.98 137.82,85.98 139.34,87.5 139.34,87.76 139.6,88.01 144.68,88.01 144.81,87.88 144.81,83.69 144.68,83.57 142.01,83.57 141,84.58 138.07,84.58 137.82,84.84 135.79,84.84 135.15,85.47 132.99,85.47 132.87,85.6 132.87,85.85
N236903807 on BOTTOM: 127.79,87.25 131.09,87.25 131.34,87 131.34,86.11 131.47,85.98 132.49,85.98 132.61,85.85 132.61,85.34 132.74,85.22 135.03,85.22 135.15,85.09 135.15,84.84 135.03,84.71 133.38,84.71 132.99,84.33 132.99,83.06 132.74,82.8 127.79,82.8 127.66,82.93 127.66,87.12

Small or netless copper shapes (teardrops, artwork): 9 on TOP, 9 on BOTTOM, 10 on IN1, 10 on IN2, 10 on IN3

## Text on the board
Ref Des/Silkscreen Bottom: I | H | G | M | K | L | C | J | B | A | E | F | D
Ref Des/Silkscreen Top: C | D | E | F | A | B | 1090100008010P
GND2: GND2
User.29: IN4
User.31: FIGURE | FINISHED_SIZE | 8.0 | 10.0 | 12.0 | 28.0 | 32.0 | 35.0 | 40.0 | 51.0 | 55.0 | 91.0 | 158.0 | 166.0 | 177.0 | 43.0 | 63.0 | 118.0 | 91.0x31.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | ROTATION | - | 90.000 | PLATED | NON-PLATED | QTY | 596 | 3910 | 780 | 50 | 126 | 12 | 28 | 7 | 6 | 2 | 3 | 9 | 4 | 14 | 5565 | TOTAL HOLES:
