# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LED_ON1: length 75.9
  TOP w0.254: Z1.2 R63.1 Q6.D 147.4,68.96 v1(147.35,68.91)
  IN1 w0.203: v1(152.32,14.22) 152.29,14.25 152.29,14.98 153.06,15.75 153.06,18.49 150.62,20.93 147.5,20.93 143.96,24.48 142.85,27.15 142.85,32.82 137.19,38.48 137.19,48 137.49,48.3 137.49,52.81 138.09,53.41 138.09,57.42 141.15,60.48 141.15,64.49 145.57,68.91 v1(147.35,68.91)
  BOTTOM w0.203: v1(152.32,14.22) TP18.7
  BOTTOM w0.254: v1(147.35,68.91) 147.42,68.91 148.11,69.6 R58.1
LED_ON1#: length 3.9
  TOP w0.203: U13.4 144.53,67.8 145.06,68.33 145.06,69.09 145.58,69.61 Q6.G
LED_ON2: length 77.4
  TOP w0.203: Q7.D v1(148.87,71.63)
  TOP w0.254: v1(148.87,71.63) Z5.2 R64.1
  IN1 w0.203: v1(148.87,71.63) 148.87,68.33 148.22,67.68 144.8,67.68 141.48,64.35 141.48,60.34 138.42,57.28 138.42,53.27 137.82,52.67 137.82,48.16 137.52,47.86 137.52,38.62 143.18,32.96 143.18,27.21 144.23,24.66 147.64,21.26 150.76,21.26 153.39,18.63 153.39,15.61 152.79,15.01 152.79,13.79 v1(152.82,13.77)
  BOTTOM w0.203: v1(152.82,13.77) TP18.6
  BOTTOM w0.254: v1(148.87,71.63) Z5.2
LED_ON2#: length 3.1
  TOP w0.203: Q7.G 145.03,73.3 U13.15
LED_ON3: length 80.3
  TOP w0.254: R65.1 Z6.2 v1(148.87,74.3) Q8.D
  IN1 w0.203: v1(148.87,74.3) 149.38,73.79 149.38,68.33 148.4,67.35 144.94,67.35 141.81,64.22 141.81,60.2 138.75,57.15 138.75,53.13 138.15,52.53 138.15,48.03 137.85,47.72 137.85,38.76 143.51,33.1 143.51,27.28 144.51,24.85 147.78,21.59 150.9,21.59 153.72,18.76 153.72,15.47 153.29,15.04 153.29,14.25 v1(153.32,14.22)
  BOTTOM w0.203: v1(153.32,14.22) TP18.5
  BOTTOM w0.254: Z6.2 v1(148.87,74.3)
LED_ON3#: length 3.2
  TOP w0.203: Q8.G 144.9,73.8 U13.16
LOUT-L: length 8.3
  BOTTOM w0.381: AUDIO1.9 157.34,154.58 156.55,155.36 C838.1 150.89,155.36 FB41.2
LOUT-R: length 4.6
  BOTTOM w0.381: AUDIO1.10 155.23,153.2 C839.1 151.07,153.2 FB40.1
M2_5G_PLTRST_N: length 101
  TOP w0.107: U88.6 118.6,110.07 119.28,110.74 v1(126.01,110.74)
  IN3 w0.124: v1(126.01,110.74) 126.06,110.8 126.06,130 127.49,131.42 127.49,139.76 127.81,140.08 127.81,141.07 127.55,141.33 127.55,151.16 127.95,151.56 127.95,158.3 128.5,158.85 132.18,158.85 135.31,161.98 135.31,165.63 143.69,174.02 143.69,182.68 144.65,183.64 v1(144.65,187.83)
  BOTTOM w0.107: NGFF1.50 147.74,187.92 147.7,187.96 144.78,187.96 v1(144.65,187.83)
M2_B_EN: length 2.6
  BOTTOM w0.107: U32.8 140.72,175.9 140.31,175.49 R223.1 RZ147.2
M2_B_PG: length 2.8
  BOTTOM w0.107: U32.3 139.78,177.66 139.61,177.84 CM64.1 139.61,179.51 139.81,179.71 RA51.2
M2_WIFI_PLTRST_N: length 60.2
  TOP w0.107: v1(126.77,110.74) 124.61,108.58 120.04,108.58 119.9,108.45 U88.4
  IN1 w0.124: v1(126.77,110.74) 126.77,112.7 129.9,115.82 152.04,115.82 152.81,116.59 152.81,124.97 151.03,126.75 146.71,126.75 v1(145.31,128.14)
  BOTTOM w0.107: R191.1 144.99,132.95 WIFI1.52 144.99,128.47 v1(145.31,128.14)
M2E_ALERT_N: length 65.9
  TOP w0.107: J1.B55 101.3,119.91 101.4,120.01 v1(101.4,120.02)
  BOTTOM w0.107: v1(101.4,120.02) 101.78,120.02 103.45,118.34 106.44,118.34 107.03,118.93 110.7,118.93 111,118.63 128.82,118.63 129.78,119.59 129.78,125.51 130.97,126.7 141.4,126.7 141.99,126.11 148.34,126.11 149.86,127.64 149.86,128.78 151.13,130.05 151.13,133.73 150.77,134.09 RZ169.2
M2E_AP_WAKE_BT: length 57
  TOP w0.107: RZ25.2 118.52,117.14 126.39,122.63 129.41,125.65 v1(129.41,126.24) ; RZ22.1 v1(149.22,127.89)
  IN1 w0.124: v1(135.79,129.03) 134.72,129.03 132.14,126.45 129.63,126.45 v1(129.41,126.24)
  BOTTOM w0.107: v1(135.79,129.03) 137.06,129.03 138.07,130.05 138.07,132.33 136.92,133.49 Q52.4 136.92,134.13 137.03,134.24 140.23,134.24 R193.1 RZU42.2 ; v1(149.22,127.89) 148.34,127 142.82,127 142.65,127.17 130.31,127.17 129.41,126.27 v1(129.41,126.24)
M2E_AP_WAKE_BT_CON: length 8.8
  BOTTOM w0.107: Q52.3 137.24,135.64 143.26,135.64 143.61,135.28 R192.1 RZ170.2
M2E_BT_DISABLE_N: length 32.8
  TOP w0.107: J1.F55 101.3,125.82 v1(101.1,126.02)
  IN3 w0.124: v1(101.1,126.02) 101.1,126.12 101.85,126.87 101.85,129.29 101.47,129.67 101.47,130.94 103.76,133.22 v1(103.76,133.73)
  BOTTOM w0.107: v1(103.76,133.73) 104.14,134.11 124.59,134.11 124.82,133.88 R201.1 125.77,133.88 125.86,133.97 Q54.1
M2E_BT_WAKE: length 38.4
  TOP w0.107: v1(100.85,130.52) 101.1,130.26 J1.J55
  BOTTOM w0.107: Q52.1 135.61,135.59 133.56,135.59 133.38,135.4 R187.1 132.33,135.13 130.5,133.3 125.07,133.3 124.04,132.27 112.57,132.27 111.84,133 103.54,133 101.05,130.52 v1(100.85,130.52)
M2E_SAR_TOUT: length 37.3
  TOP w0.107: RZ21.1 v1(148.08,127.89)
  BOTTOM w0.107: RZ171.2 123.13,128.02 123.75,127.4 142.75,127.4 142.92,127.23 147.43,127.23 v1(148.08,127.89)
M2E_SDIO_EN: length 112.1
  TOP w0.107: J1.B58 v1(104,120.02) ; RZU17.1 v1(142.62,126.62)
  IN1 w0.124: v1(142.62,126.62) 142.55,126.62 142.42,126.75 142.42,127.51 arc(142.34,127.69) 142.16,127.76 141.91,127.76 arc(141.75,127.7) 141.68,127.54 141.68,126.88 arc(141.61,126.69) 141.43,126.62 141.22,126.62 arc(141.03,126.7) 140.95,126.89 140.95,128.45 arc(140.88,128.61) 140.72,128.68 140.47,128.68 arc(140.29,128.6) 140.22,128.42 140.22,126.86 arc(140.15,126.69) 139.98,126.62 139.74,126.62 arc(139.56,126.69) 139.48,126.87 139.48,128.42 arc(139.41,128.6) 139.23,128.68 138.99,128.68 arc(138.82,128.61) 138.75,128.44 138.75,126.85 arc(138.68,126.69) 138.51,126.62 138.27,126.62 arc(138.09,126.69) 138.01,126.87 138.01,128.44 arc(137.94,128.61) 137.77,128.68 137.52,128.68 arc(137.35,128.61) 137.28,128.44 137.28,126.89 arc(137.2,126.7) 137.01,126.62 136.8,126.62 arc(136.62,126.69) 136.55,126.87 136.55,128.3 arc(136.46,128.49) 136.27,128.57 136.09,128.57 arc(135.89,128.49) 135.81,128.3 135.81,126.87 arc(135.74,126.69) 135.56,126.62 135.31,126.62 arc(135.14,126.69) 135.08,126.85 135.08,127.91 arc(135.01,128.08) 134.85,128.14 134.59,128.14 arc(134.42,128.07) 134.34,127.89 134.34,126.85 arc(134.28,126.69) 134.11,126.62 133.05,126.62 132.85,126.42 132.85,123.4 arc(132.76,123.18) 132.54,123.09 132.06,123.09 arc(131.86,123.17) 131.78,123.37 131.78,124.46 arc(131.7,124.66) 131.5,124.74 131.27,124.74 arc(131.11,124.67) 131.05,124.52 131.05,123.38 arc(130.96,123.17) 130.76,123.09 130.61,123.09 arc(130.4,123.17) 130.31,123.38 130.31,124.47 arc(130.24,124.66) 130.05,124.74 129.84,124.74 arc(129.66,124.66) 129.58,124.47 129.58,123.36 arc(129.5,123.17) 129.31,123.09 129.12,123.09 arc(128.93,123.17) 128.84,123.37 128.84,124.44 arc(128.76,124.65) 128.55,124.74 128.4,124.74 arc(128.19,124.66) 128.11,124.45 128.11,123.36 arc(128.03,123.17) 127.84,123.09 127.66,123.09 arc(127.46,123.17) 127.38,123.37 127.38,124.46 arc(127.3,124.66) 127.1,124.74 126.95,124.74 arc(126.73,124.65) 126.64,124.43 126.64,123.43 arc(126.28,123.06) 125.91,123.43 125.91,124.48 arc(125.83,124.66) 125.65,124.74 124.89,124.74 arc(124.68,124.65) 124.59,124.44 124.59,121.58 arc(124.48,121.32) 124.22,121.21 124.21,121.21 arc(123.96,121.31) 123.86,121.56 123.86,125.6 arc(123.78,125.78) 123.6,125.86 123.38,125.86 arc(123.2,125.78) 123.12,125.6 123.12,120.45 arc(123.01,120.18) 122.74,120.07 121.37,120.07 arc(121.13,120.16) 121.04,120.4 121.04,125.12 arc(120.97,125.28) 120.81,125.35 120.55,125.35 arc(120.37,125.28) 120.3,125.1 120.3,120.35 arc(120.23,120.19) 120.07,120.12 119.77,120.12 arc(119.63,120.18) 119.57,120.32 119.57,124.03 arc(119.49,124.21) 119.31,124.28 119.06,124.28 arc(118.9,124.22) 118.83,124.05 118.83,120.37 arc(118.76,120.19) 118.58,120.12 117.99,120.12 arc(117.82,120.18) 117.76,120.35 117.76,122.89 arc(117.69,123.05) 117.53,123.11 117.25,123.11 arc(117.09,123.05) 117.02,122.89 117.02,120.4 arc(116.94,120.2) 116.74,120.12 106.63,120.12 106.26,120.48 104.47,120.48 v1(104,120.02)
M2E_SDIO_WAKE: length 114.6
  TOP w0.107: R1483.1 139.85,127.64 RZU12.1 139.83,127.8 139.09,128.54 134.59,128.54 127.67,135.47 127.67,137.7 125.01,140.36 116.41,140.36 112.62,144.15 74.81,144.15 arc(74.56,144.05) 74.46,143.8 74.46,142.71 arc(74.38,142.5) 74.17,142.42 74.04,142.42 arc(73.81,142.51) 73.72,142.74 73.72,143.64 arc(73.64,143.82) 73.46,143.9 73.21,143.9 arc(73.05,143.83) 72.98,143.66 72.98,142.72 arc(72.89,142.51) 72.67,142.42 72.52,142.42 arc(72.32,142.5) 72.24,142.7 72.24,143.64 arc(72.16,143.82) 71.98,143.9 71.75,143.9 arc(71.57,143.82) 71.49,143.64 71.49,142.67 arc(71.42,142.49) 71.25,142.42 70.99,142.42 arc(70.82,142.49) 70.75,142.66 70.75,143.63 arc(70.67,143.82) 70.48,143.9 70.27,143.9 arc(70.09,143.82) 70.01,143.64 70.01,142.62 arc(69.95,142.48) 69.81,142.42 69.52,142.42 arc(69.36,142.48) 69.29,142.65 69.29,143.63 arc(69.22,143.82) 69.04,143.89 68.81,143.89 arc(68.65,143.82) 68.58,143.66 68.58,142.64 arc(68.51,142.48) 68.35,142.42 66.56,142.42 64.87,140.73 55.41,140.73 v1(54.99,140.31) ; J1.L6 54.2,133.4 54.31,133.5 v1(54.42,133.5)
  IN3 w0.124: v1(54.42,133.5) 54.42,136.21 55.12,136.9 55.12,140.18 v1(54.99,140.31)
M2E_WIFI_DISABLE_N: length 86.7
  TOP w0.107: v1(124.21,136.55) 123.55,136.55 122.44,137.66 115.29,137.66 111.5,141.45 96.62,141.45 94.82,139.65 67.61,139.65 65.44,137.47 53.03,137.47 v1(52.7,137.79) ; J1.J4 v1(52.4,130.52)
  IN3 w0.124: v1(52.4,130.52) 51.08,131.84 51.08,135.64 52.7,137.27 v1(52.7,137.79)
  BOTTOM w0.107: v1(124.21,136.55) R198.1 125.31,136.64 Q53.4
M2E_WIFI_WAKE: length 69.3
  TOP w0.107: v1(100.74,111.02) 99.32,111.02 99.21,110.92 R3.1 99.21,109.86 99.05,109.69 Q50.S ; v1(143.92,128.14) 144.4,127.66 RZU16.1 144.78,127.46 144.86,127.38 Q17.S 145.53,127.47 R196.2 ; v1(101.23,127.52) 101.1,127.39 J1.G55
  IN3 w0.124: v1(101.23,127.52) 100.63,126.92 100.63,121.67 101.81,120.48 101.81,119.32 101.33,118.83 101.33,111.61 v1(100.74,111.02)
  BOTTOM w0.107: v1(101.23,127.52) 101.47,127.76 102.11,127.76 102.87,128.52 122.96,128.52 123.85,127.64 143.41,127.64 v1(143.92,128.14)
M2M_ALERT_N: length 62.4
  TOP w0.107: SSD2.44 v1(148.31,110.74) 148.31,110.29 R757.1 ; J1.A55 101.68,117.28 102.63,116.95 106.68,116.22 113.53,116.22 113.91,116.6 118.18,116.6 125.64,121.79 132.45,124.19 v1(133.48,125.22)
  IN3 w0.124: v1(133.48,125.22) 133.73,125.22 134.09,124.86 134.09,123.18 137.38,119.89 137.38,116.39 141.7,112.06 145.85,112.06 147.17,110.74 v1(148.31,110.74)
M.2_BT_RF_KILL#: length 23.3
  BOTTOM w0.107: Q54.6 129.5,133.97 R200.1 130.58,134.14 133.01,136.57 135.97,136.57 136.28,136.27 144.58,136.27 145.67,135.18 145.67,132.31 145.49,132.13 WIFI1.54
M.2_RESET: length 1.8
  BOTTOM w0.107: NGFF1.67 156.6,192.17 R222.2
M.2_WIFI_RF_KILL#: length 22.7
  BOTTOM w0.107: Q53.3 129.63,136.64 R197.1 130.91,136.68 131.04,136.8 136.07,136.8 136.37,136.5 144.68,136.5 145.92,135.25 145.92,132.33 145.99,132.27 WIFI1.56
M.2_WIFI_SUS_CLK: length 5.6
  TOP w0.107: R194.2 144.15,135.89 144.49,135.55 v1(144.49,134.83)
  BOTTOM w0.107: WIFI1.50 v1(144.49,134.83)
MCLK01_AUDIO_MCLK: length 92.7
  TOP w0.107: J1.H9 57.1,128.47 v1(56.55,129.02) ; v1(57.68,142.67) 57.71,142.67 58.22,143.18 60.38,143.18 63.73,146.53 114.15,146.53 118,150.39 131.04,150.39 v1(131.32,150.11)
  IN3 w0.124: v1(56.55,129.02) 56.55,129.47 57.68,130.6 v1(57.68,142.67)
  BOTTOM w0.107: RZ155.1 v1(131.32,150.11)
MCLK02_CAM0_MCLK: length 34.7
  TOP w0.107: J14.91 v1(116.5,154.56) ; v1(101.73,140.72) 100.97,140.72 100.58,140.34 RZ16.1
  IN1 w0.124: v1(101.73,140.72) 101.73,142.7 111.47,152.44 112.46,152.44 114.58,154.56 v1(116.5,154.56)
MCLK02_MCLK: length 9.1
  TOP w0.107: RZ16.2 100.58,136.14 99.75,135.31 99.75,132.41 99.95,132.21 99.95,130.55 100.2,130.3 J1.J54
MCLK03_CAM1_MCLK: length 44.2
  TOP w0.107: J14.88 v1(115.5,172.72) ; v1(98.3,140.08) RZ14.1
  IN3 w0.124: v1(98.3,140.08) 100.25,142.04 103.33,142.04 103.95,142.66 103.95,156.59 110.45,163.09 111.13,163.09 115.5,167.45 v1(115.5,172.72)
MCLK03_MCLK: length 10.8
  TOP w0.107: RZ14.2 98.3,134.54 98.85,133.99 98.85,132.29 99.05,132.09 99.05,130.93 98.85,130.73 98.85,129.37 99.5,128.72 J1.H53
MCLK04_CAM2_MCLK: length 42.9
  TOP w0.107: J14.94 v1(117,173.23) ; RZ17.1 v1(101.73,140.08)
  IN3 w0.124: v1(117,173.23) 117,170.92 116.89,170.82 116.89,168.24 111.31,162.66 110.62,162.66 104.38,156.41 104.38,142.3 102.16,140.08 v1(101.73,140.08)
MCLK04_MCLK: length 10.4
  TOP w0.107: J1.H55 101.3,128.99 101.55,129.24 101.55,130.79 101.75,130.99 101.75,132.29 101.55,132.49 101.55,133.22 101.73,133.4 RZ17.2
MCU2_FLASH#: length 105.9
  TOP w0.107: J1.C61 v1(106.5,121.52)
  IN1 w0.124: v1(106.5,121.52) 106.99,121.03 111.2,121.03 112.06,121.89 115.24,121.89 117.78,124.43 118.17,124.43 120.7,126.95 124.82,126.95 126.06,125.7 131.72,125.7 v1(132.21,125.22)
  IN3 w0.124: v1(139.83,72.01) 140.36,72.01 143.85,75.5 150.53,75.5 153.19,78.16 153.19,96.32 152.1,97.41 152.1,100.07 149.33,102.84 149.33,108.1 145.62,111.81 141.6,111.81 137.13,116.28 137.13,119.66 134.47,122.33 132.87,122.33 131.75,123.44 131.75,124.92 132.05,125.22 v1(132.21,125.22)
  BOTTOM w0.107: RZ203.1 v1(139.83,72.01)
MCU2_RST#: length 51.9
  TOP w0.107: R81.1 141.29,61.23 C24.1 ; C24.1 141.29,63.33 141.33,63.37 U13.64 ; C24.1 v1(140.61,62.36)
  BOTTOM w0.107: SW2.4 SW2.3 112.45,48.23 110.51,50.17 110.51,56 114.2,59.69 118.21,59.69 119.23,60.71 DB1.10 121.31,60.71 123.12,62.51 132.72,62.51 133.18,62.05 138.4,62.05 139.22,62.87 140.36,62.87 140.61,62.61 v1(140.61,62.36)
MCU2_VDD: length 49.7
  TOP w0.203: U14.14 127.37,73.86 CA70.1 127.32,74.26 U14.15
  TOP w0.254: v1(137.44,65.41) 137.33,65.29 U13.56 137.33,63.36 v1(137.57,63.12) ; U13.34 v1(132.99,73.3) ; v1(137.95,74.68) 137.83,74.8 U13.24 v1(137.83,76.96)
  TOP w0.279: v1(144.55,69.72) 144.48,69.8 U13.8 v1(142.27,69.8) ; U13.34 v1(130.6,73.3)
  TOP w0.508: R90.1 v1(129.31,76.2) ; RB48.2 RB49.2 v1(125.09,78.49) ; v1(124.97,70.23) RB54.2 RB53.2 ; RB52.2 RB53.2 ; RB53.2 v1(123.85,70.23) ; R1477.1 v1(116.87,75.29) ; RB50.2 v1(122.12,73.66) ; RB55.2 v1(121.69,69.82) ; CA71.1 127.7,73.25 v1(127.67,73.28) CA70.1 ; RB51.2 v1(121.06,73.15) ; FB2.1 v1(141.73,80.29) ; RB47.2 v1(121.67,78.49) ; R81.2 v1(142.9,61.21) ; R84.2 v1(135.25,80.26)
  BOTTOM w0.381: v1(137.57,63.12) 137.5,63.18 CA152.1 C19.1 137.5,65.34 v1(137.44,65.41)
  BOTTOM w0.508: R1500.2 v1(136.17,70.36) ; v1(137.95,74.68) 138.01,74.74 CA149.1 C18.1 138.01,76.78 v1(137.83,76.96) ; R62.2 v1(144.68,72.52) ; R85.2 148.72,66.9 150.62,68.81 R58.2 v1(150.62,70.87) R57.2 v1(150.62,73.53) R56.2 ; DB1.1 v1(116.23,66.67) ; v1(130.6,73.3) 130.67,73.37 C20.1 C21.1 132.92,73.37 v1(132.99,73.3) ; v1(144.55,69.72) 144.46,69.63 CA150.1 CA151.1 142.43,69.63 v1(142.27,69.8) ; v1(130.45,70.84) R1491.2 ; R1498.2 v1(136.19,69.22) ; R1499.2 v1(134.9,76.96) ; R1505.2 v1(136.17,71.5)
  vias: v1(143.41,79.25) v1(144.32,78.36)
MCU2_VDD_REF: length 8.9
  TOP w0.254: U13.22 138.83,77.46 139.22,77.85 C23.1 ; U13.23 138.33,77.35 138.07,77.6 CA69.1
  TOP w0.508: CA69.1 C23.1 C22.1 141.47,78.27 FB2.2
MCU_BUZZ: length 276.2
  TOP w0.254: U13.41 130.53,69.8 v1(130.45,69.72) ; RZ1.1 v1(11.96,194.21)
  IN3 w0.254: v1(21.49,82.85) 21.62,82.85 22.1,82.37 34.77,82.37 36.78,80.37 36.78,72.59 46,63.37 46,59.88 46.95,58.93 49.37,58.93 50.89,57.4 58.34,57.4 58.83,56.92 67.92,56.92 69.74,55.11 74.97,55.11 76.53,53.54 81.98,53.54 83.68,55.25 86.26,55.25 86.99,55.97 92.25,55.97 97.34,61.06 105.13,61.06 106.44,62.37 108.98,62.37 111.15,60.2 v1(112.17,60.2)
  BOTTOM w0.254: v1(11.96,194.21) 8.53,194.21 5.89,191.57 5.89,168.65 2.16,164.91 2.16,100.08 4.67,97.57 4.67,85.73 7.4,83.01 21.34,83.01 v1(21.49,82.85) ; v1(112.17,60.2) 113.69,61.72 113.69,67.73 115.15,69.19 129.01,69.19 R1491.1 130.3,69.88 v1(130.45,69.72)
MCU_CARRIER_POWER_ON: length 6.9
  TOP w0.107: 108.07,137.81 107.96,137.91 U4.1 ; 108.07,137.81 108.34,137.81 108.46,137.92 U4.2 ; 108.07,137.81 107.4,137.14 J1.L62
MCU_IRQ#: length 76.6
  TOP w0.107: v1(118.24,122.17) 118.24,122.96 118.34,123.06 Q59.D ; U13.19 v1(140.33,76.96)
  IN3 w0.124: v1(118.24,122.17) 118.9,122.17 119.43,121.64 119.43,112.75 117.73,111.05 117.73,107.2 112.92,102.39 112.92,97.74 114.39,96.26 114.39,81.85 116.87,79.38 127.03,79.38 128.68,77.72 139.56,77.72 v1(140.33,76.96)
  BOTTOM w0.107: R1490.1 v1(118.24,122.17)
MCU_OP_A: length 3.4
  TOP w0.203: v1(90.7,82.55) 91.09,82.93 U66.16
  BOTTOM w0.381: RZU28.1 R539.1 90.68,82.58 v1(90.7,82.55)
MCU_P25_A: length 1.5
  TOP w0.203: U66.60 v1(93.89,90.63)
  BOTTOM w0.203: v1(93.89,90.63) 93.85,90.08 R515.1
MCU_P70_RXD: length 64.7
  TOP w0.107: v1(60.78,77.17) 60.78,77.93 63.55,80.7 70.92,80.7 71.37,81.15 75.03,81.15 79.82,85.94 84.44,85.94 86.89,88.39 86.89,89.66 87.4,90.17 88.51,90.17 88.62,90.06 R532.1 89.17,89.66 89.56,89.28 89.56,88.52 90.34,87.73 U66.4
  BOTTOM w0.107: RZU47.1 41.76,74.19 42.22,74.66 52.38,74.66 53.39,75.67 59.28,75.67 v1(60.78,77.17)
MCU_P71_TXD: length 63.2
  TOP w0.107: U66.5 90.9,87.33 90.86,87.38 90.07,87.38 88.93,88.52 R533.1 88.62,88.12 88.51,88.01 87.15,88.01 84.68,85.55 79.93,85.55 75.18,80.8 71.55,80.8 71.09,80.34 63.7,80.34 61.29,77.93 61.29,76.91 v1(60.78,76.4)
  BOTTOM w0.107: RZU46.1 41.15,72.92 42.47,74.24 52.44,74.24 53.53,75.34 59.46,75.34 60.53,76.4 v1(60.78,76.4)
MCU_SCL_A: length 16.9
  TOP w0.107: U66.9 89.95,85.73 v1(89.69,85.47) 89.31,85.09 R537.2 ; U66.38 99.92,84.93 99.95,84.91 v1(99.97,84.91)
  IN3 w0.124: v1(99.97,84.91) 99.3,84.24 99.3,83.25 98.68,82.63 92.53,82.63 91.72,83.44 91.72,84.25 90.5,85.47 v1(89.69,85.47)
MCU_SDA_A: length 17.8
  TOP w0.107: U66.37 99.77,84.53 99.8,84.5 100.33,84.5 100.58,84.25 v1(100.58,84.02) ; U66.10 90.44,85.33 v1(89.69,84.58) 89.05,83.95 R538.2
  IN3 w0.124: v1(100.58,84.02) 100.58,83.92 98.86,82.2 92.35,82.2 91.29,83.26 91.29,83.94 90.65,84.58 v1(89.69,84.58)
MCU_VDD: length 11.2
  TOP w0.508: v1(143.66,100.71) 141.3,100.71 140.41,99.82 140.41,97.92 139.55,97.05 C413.1
  BOTTOM w0.254: v1(144.42,93.48) CB136.1 143.9,93.62 U77.5
  BOTTOM w0.508: R697.2 v1(143.66,100.71)
  vias: v1(131.98,97.54) v1(132.61,97.54) v1(133.25,97.54) v1(133.25,96.9) v1(133.25,96.27) v1(133.25,95.63) v1(133.25,95) v1(133.25,94.36) v1(136.55,97.54) v1(136.55,96.9) v1(136.55,96.27) v1(136.55,95.63) v1(136.55,95) v1(136.55,94.36) v1(137.19,96.01) v1(137.19,95.38) v1(145.8,78.38) v1(146.58,79.25)
MCU_VDD_EN: length 4.4
  BOTTOM w0.254: U77.12 144.9,98.17 C417.1 146.16,99.44 D64.C R696.1
MOD_SHUTDOWN_N: length 27
  TOP w0.107: J1.L52 98.4,133.83 97.54,134.7 v1(97.54,136.78) ; v1(109.21,152.41) 109.2,152.4 U10.2
  IN1 w0.124: v1(109.21,152.41) 108.56,151.76 107.82,151.76 98.83,142.77 98.83,138.07 v1(97.54,136.78)
  BOTTOM w0.107: v1(109.21,152.41) 109.21,151.88 R46.2
MOD_SHUTDOWN_N_3V3: length 4.4
  TOP w0.107: U10.4 109.85,154.06 109.6,154.31 108.71,154.31 108.56,154.46 U11.1 108.37,155.47 108.1,155.47 107.85,155.22 RB12.2
MOD_TEMP_SHDN_EN_N: length 12.1
  TOP w0.107: J1.J62 107.15,130.11 107.15,131.66 107.85,132.36 107.85,136.81 108.33,137.29 110.74,137.29 111.25,137.79 RZ13.1
MODULE_POWER_ON: length 51.2
  TOP w0.107: J1.L54 v1(100.2,133.48) ; U7.3 129.69,163.86 RZU3.1 v1(128.78,163.07) 128.3,162.59 R29.1
  IN1 w0.124: v1(128.78,163.07) 128.78,162.15 124.74,158.12 124.74,156.69 123.24,155.19 113.26,155.19 100.61,142.54 100.61,133.89 v1(100.2,133.48)
N_SIN1: length 22.7
  TOP w0.107: U25.3 84.88,162.16 83.08,163.96 83.08,170.91 89.54,177.37 90.28,177.37 90.83,177.93 U24.5
N_SIN2: length 28.6
  TOP w0.107: v1(83.64,165.43) 83.64,171.15 89.64,177.14 90.86,177.14 92.1,178.38 U24.6 ; U25.22 79.23,157.84 v1(79.58,158.19)
  IN1 w0.124: v1(83.64,165.43) 79.58,161.37 v1(79.58,158.19)
N_SIN3: length 31.7
  TOP w0.107: U25.41 82.88,153.36 v1(83.19,153.67)
  BOTTOM w0.107: U26.5 89.56,176.01 89.03,175.47 86.42,175.47 84.37,173.42 84.37,160.44 82.75,158.83 82.75,154.1 v1(83.19,153.67)
N_SIN4: length 26.6
  TOP w0.107: U25.64 v1(83.13,159.84)
  BOTTOM w0.107: v1(83.13,159.84) 84.13,160.85 84.13,173.52 86.32,175.71 87.88,175.71 88.29,176.11 U26.6
N_SOUT1: length 23.4
  TOP w0.107: U24.3 88.29,176.79 82.61,171.11 82.61,166.81 v1(82.12,166.32) ; U25.2 v1(85.28,162.51)
  IN1 w0.124: v1(85.28,162.51) 85.28,165.19 84.15,166.32 v1(82.12,166.32)
N_SOUT2: length 28.1
  TOP w0.107: U25.21 77.6,158.25 v1(77.29,157.94) ; U24.4 89.56,177.72 82.84,171.01 82.84,166.16 v1(82.12,165.43)
  IN1 w0.124: v1(82.12,165.43) 82.12,164.8 78.82,161.49 78.82,159.08 77.67,157.94 v1(77.29,157.94)
N_SOUT3: length 33.3
  TOP w0.107: v1(83.19,154.43) 82.48,153.72 U25.40
  BOTTOM w0.107: U26.3 92.1,176.68 90.42,175.01 86.61,175.01 84.84,173.23 84.84,159.64 83.19,157.99 v1(83.19,154.43)
N_SOUT4: length 28.9
  TOP w0.107: v1(83.64,159.08) 84.01,159.44 U25.63
  BOTTOM w0.107: v1(83.64,159.08) 84.6,160.04 84.6,173.33 86.52,175.24 89.79,175.24 90.83,176.28 U26.4
NC_SI1_ARB_IN: length 1.5
  BOTTOM w0.107: U41.43 30.49,31.64 RA89.2
NC_SI1_ARB_OUT: length 1.7
  BOTTOM w0.107: U41.44 29.61,31.14 29.8,31.34 30.37,31.34 RA91.2
NC_SI1_CLK: length 1.5
  TOP w0.107: RA33.2 19.25,29.46 v1(19.18,29.54)
  BOTTOM w0.107: v1(19.18,29.54) 19.23,29.59 19.3,29.59 19.36,29.64 U41.2
NC_SI1_CRS_DV: length 1.5
  TOP w0.107: v1(19.18,30.17) 19.74,30.17 RA31.2
  BOTTOM w0.107: v1(19.18,30.17) 19.28,30.17 19.3,30.14 U41.3
NC_SI1_RXD0: length 1.5
  BOTTOM w0.107: U41.6 18.66,31.64 RA90.2
NC_SI1_RXD1: length 1.5
  BOTTOM w0.107: U41.5 18.58,31.14 RA92.2
NC_SI1_TX_EN: length 1.5
  TOP w0.107: v1(19.18,32.14) 19.19,32.13 RA30.2
  BOTTOM w0.107: U41.7 v1(19.18,32.14)
NC_SI1_TXD0: length 1.6
  BOTTOM w0.107: RA76.2 18.79,33.4 19.05,33.14 U41.9
NC_SI1_TXD1: length 1.5
  BOTTOM w0.107: RA83.2 18.68,32.64 U41.8
NCSI4_ARBIN: length 1.5
  BOTTOM w0.107: U47.43 82.88,28.72 82.96,28.8 83.91,28.8 RA111.2
NCSI4_ARBOUT: length 1.7
  BOTTOM w0.203: RA123.2 83.9,28.19 83.62,28.47 83.1,28.47 82.85,28.22 U47.44
NCSI4_CLKIN: length 127.3
  TOP w0.107: RA48.2 72.62,26.54 72.52,26.44 v1(72.52,26.37)
  IN3 w0.124: v1(153.65,77.2) 152.6,76.15 152.6,71.07 151.41,69.88 146.77,69.88 145.22,68.32 141.68,68.32 137.91,64.56 131.52,64.56 130.51,63.54 125.08,63.54 121.21,59.67 116.84,59.67 112.33,55.16 112.33,48.78 110.73,47.17 109.53,47.17 105.74,43.39 99.67,43.39 98.04,41.76 90.35,41.76 90.08,41.49 71.47,41.49 67.88,37.9 67.88,29.3 68.4,28.78 68.4,27.74 70.28,25.86 72.01,25.86 v1(72.52,26.37)
  BOTTOM w0.107: v1(72.52,26.37) 72.52,26.62 72.62,26.72 U47.2 ; NCSI1.5 v1(153.65,77.2)
NCSI4_CRS_DV: length 123.6
  TOP w0.107: v1(72.09,27.25) 73.08,27.25 RA42.2
  IN3 w0.124: v1(153.65,73.2) 154.08,72.77 154.08,71.02 151.59,68.53 148.08,68.53 147.37,67.82 146.08,67.82 144.82,66.56 141.17,66.56 138.28,63.67 131.89,63.67 130.87,62.66 125.45,62.66 121.48,58.69 117.25,58.69 114.3,55.74 114.3,46.55 110.39,42.64 108.02,42.64 105,39.62 100.63,39.62 99.41,40.84 90.7,40.84 90.42,40.56 81.93,40.56 81.29,39.92 71.15,39.92 68.76,37.54 68.76,29.67 70.69,27.74 71.59,27.74 v1(72.09,27.25)
  BOTTOM w0.107: NCSI1.9 v1(153.65,73.2) ; U47.3 72.54,27.22 72.52,27.25 v1(72.09,27.25)
NCSI4_RXD0: length 123.7
  IN3 w0.124: v1(72.47,28.78) 72.41,28.72 71,28.72 69.67,30.05 69.67,37.16 71.07,38.55 87,38.55 87.63,39.19 99.77,39.19 100.25,38.71 105.38,38.71 108.4,41.73 110.77,41.73 115.21,46.18 115.21,55.36 117.63,57.78 121.85,57.78 125.82,61.75 131.25,61.75 131.49,61.99 137.89,61.99 141.54,65.65 145.23,65.65 146.47,66.88 147.72,66.88 148.46,67.62 151.99,67.62 155.02,70.65 155.02,73.8 v1(153.62,75.2)
  BOTTOM w0.107: RA112.2 71.98,28.83 72.03,28.78 v1(72.47,28.78) 72.52,28.72 U47.6 ; NCSI1.7 v1(153.62,75.2)
NCSI4_RXD1: length 123.4
  IN3 w0.124: v1(72.09,28.19) 70.88,28.19 69.22,29.86 69.22,37.35 71.34,39.47 81.48,39.47 82.12,40.1 90.61,40.1 90.89,40.38 99.22,40.38 100.44,39.17 105.19,39.17 108.21,42.19 110.58,42.19 114.76,46.37 114.76,55.55 117.44,58.23 121.67,58.23 125.63,62.2 131.06,62.2 131.38,62.52 137.77,62.52 141.35,66.1 145.05,66.1 146.28,67.34 147.54,67.34 148.27,68.07 151.8,68.07 154.56,70.84 154.56,73.26 v1(153.62,74.2)
  BOTTOM w0.107: U47.5 72.11,28.22 v1(72.09,28.19) RA124.2 ; NCSI1.8 v1(153.62,74.2)
NCSI4_TX_EN: length 120.8
  TOP w0.107: v1(72.09,29.29) 72.45,29.29 72.53,29.21 RA36.2
  IN3 w0.124: v1(156.03,79.2) 156.03,71.02 151.67,66.66 148.49,66.66 146.19,64.36 140.9,64.36 138.07,61.54 131.68,61.54 131.44,61.29 130.36,61.29 123.34,54.28 123.34,52.7 120.17,49.53 119.21,49.53 110.96,41.28 108.59,41.28 104.98,37.67 100.22,37.67 99.21,38.68 87.86,38.68 87.28,38.1 72.64,38.1 72.29,37.74 72.29,37.08 70.83,35.62 70.83,32.83 71.07,32.59 71.07,30.03 71.81,29.29 v1(72.09,29.29)
  BOTTOM w0.107: v1(72.09,29.29) 72.15,29.22 U47.7 ; NCSI1.3 v1(156.03,79.2)
NCSI4_TXD0: length 120.3
  IN3 w0.124: v1(156.06,81.2) 156.94,80.32 156.94,70.64 149.52,63.22 142.94,63.22 140.34,60.63 132.06,60.63 131.81,60.38 130.74,60.38 124.25,53.9 124.25,52.33 120.54,48.62 119.58,48.62 111.33,40.37 108.97,40.37 105.36,36.76 99.85,36.76 98.84,37.77 96.8,37.77 95.59,36.56 73.55,36.56 72.57,35.59 72.57,32.23 72.09,31.75 v1(72.09,30.3)
  BOTTOM w0.107: NCSI1.1 v1(156.06,81.2) ; U47.9 72.17,30.22 v1(72.09,30.3) 71.91,30.48 RA96.2
NCSI4_TXD1: length 120.3
  IN3 w0.124: v1(156.03,80.21) 156.49,79.76 156.49,70.83 149.33,63.68 142.75,63.68 140.15,61.08 131.87,61.08 131.63,60.84 130.55,60.84 123.8,54.09 123.8,52.52 120.36,49.08 119.4,49.08 111.15,40.83 108.78,40.83 105.17,37.21 100.04,37.21 99.02,38.22 88.05,38.22 86.84,37.02 73.23,37.02 72.11,35.9 72.11,32.42 71.63,31.94 71.63,30.11 71.95,29.79 v1(72.47,29.79)
  BOTTOM w0.107: v1(156.03,80.21) 156.02,80.2 NCSI1.2 ; U47.8 72.54,29.72 v1(72.47,29.79) 72.09,29.79 72.03,29.84 RA102.2
NVM_CS1: length 3.9
  BOTTOM w0.107: U41.15 19.48,36.14 19.05,36.58 19.05,38.21 R284.2
NVM_SI1: length 1.5
  BOTTOM w0.107: R281.2 18.68,34.67 19.43,34.67 19.46,34.64 U41.12
NVM_SK1: length 1.5
  BOTTOM w0.107: R282.2 18.59,35.14 U41.13
NVM_SO1: length 4.7
  BOTTOM w0.107: R283.2 18.54,38.09 18.54,36.45 19.35,35.64 U41.14
NVME_PCIE_WAKE_N: length 6.1
  TOP w0.107: v1(150.67,113.67) 150.67,113.13 150.81,112.99 SSD2.54
  BOTTOM w0.107: RZ178.1 149.86,112.67 150.67,113.49 v1(150.67,113.67) R759.1
OVCUR1#: length 5.8
  TOP w0.107: U20.19 87.17,70.15 87.86,70.84 90.98,70.84 91.15,70.68 RA6.2 RZ74.1
OVCUR2#: length 4.1
  TOP w0.203: RA10.2 88.21,61.8 87.66,62.36 87.66,63.09 87.4,63.35 U20.2
  TOP w0.254: RA10.2 88.48,61.18 88.7,61.39 RZ95.1
OVCUR3#: length 2
  TOP w0.107: U20.54 77.29,64.15 76.85,63.7 RA9.2
OVCUR4#: length 3.3
  TOP w0.107: RA5.2 77.04,71.83 77.29,71.58 77.29,69.93 77.47,69.75 U20.40
P0_TOD_CLK_IN_3V3: length 1.8
  BOTTOM w0.107: U85.8 142.52,104.16 142.88,104.52 RZ41.1
P1_TOD_CLK_IN_3V3: length 2.1
  BOTTOM w0.107: RZ47.1 142.18,104.56 U85.7
P_SPI_CK: length 12.9
  TOP w0.107: U21.6 v1(85.55,77.47) ; v1(87.63,68.15) U20.14
  IN1 w0.124: v1(87.63,68.15) 87.38,68.15 86.57,68.96 86.57,71.75 86.94,72.13 86.94,76.66 86.13,77.47 v1(85.55,77.47)
P_SPI_CZ: length 19.8
  TOP w0.107: U21.1 v1(82.12,80.01) ; v1(87.81,69.09) 87.73,69.09 87.59,68.95 U20.16
  IN1 w0.124: v1(82.12,80.01) 85.02,80.01 88.34,76.69 88.34,71.62 87.62,70.9 87.62,69.28 v1(87.81,69.09)
P_SPI_DI: length 20.2
  TOP w0.107: U20.15 87.43,68.55 87.44,68.56 88.12,68.56 v1(88.16,68.61) ; U21.2 v1(82.12,78.74)
  IN1 w0.124: v1(82.12,78.74) 85.58,78.74 87.84,76.48 87.84,71.83 87.07,71.07 87.07,69.09 87.55,68.61 v1(88.16,68.61)
P_SPI_DO: length 14.5
  TOP w0.107: v1(88.21,68.02) 88.09,68.02 87.78,67.72 87.43,67.72 87.4,67.75 U20.13 ; U21.5 84.99,76.2 v1(85.55,76.76)
  IN1 w0.124: v1(88.21,68.02) 87.83,67.64 87.07,67.64 86.06,68.65 86.06,71.96 86.44,72.34 86.44,76.35 86.03,76.76 v1(85.55,76.76)
P_SPI_HOLD#: length 1.8
  TOP w0.107: RA3.2 85.74,78.74 U21.7
P_SPI_WP#: length 1.6
  TOP w0.107: RA4.2 77.33,77.47 U21.3
PCIE1_CLKREQ_N: length 66.8
  TOP w0.107: v1(84.33,119.89) 84.33,119.73 J1.B37
  IN1 w0.124: v1(84.33,119.89) 87.89,116.33 122.62,116.33 127.21,120.91 133.62,120.91 135.28,122.58 143.33,122.58 144.42,121.49 v1(144.42,120.68)
  BOTTOM w0.107: RZ174.1 v1(144.42,120.68)
PCIE1_RST_N: length 49.7
  TOP w0.107: U88.3 119.9,105.55 119.76,105.41 118.75,105.41 118.6,105.55 ; 118.6,105.55 U88.1 ; 118.6,105.55 118.46,105.41 116.87,105.41 116.73,105.55 ; v1(114.71,115.7) 114.6,115.7 114.47,115.83 106.59,115.83 94.67,116.99 89.38,117.3 84.4,117.3 84.25,117.45 84.25,118.31 83.8,118.76 J1.B36 ; 116.73,105.55 116.59,105.41 115.54,105.41 115.43,105.53 U89.1 v1(115.43,106.91) ; 116.73,105.55 U89.3
  IN3 w0.124: v1(115.43,106.91) 114.71,107.63 v1(114.71,115.7)
PCIE4_CLK_N: length 88
  TOP w0.114: v1(150.46,116.78) 150.68,117.01 150.68,117.54 150.56,117.66 SSD2.53 ; v3(69.98,124.5) 70.1,124.37 70.1,123.98 69.99,123.86 J1.E22
  BOTTOM w0.114: v3(69.98,124.5) 70.12,124.36 70.12,124.06 70.39,123.8 80.92,123.8 82.26,122.46 83.35,121.96 84.47,120.83 84.93,120.58 85.28,120.24 arc(85.31,120.19) 85.32,120.13 85.32,119.82 arc(85.41,119.34) 85.69,118.94 86.37,118.25 arc(87.21,117.65) 88.19,117.33 91.37,116.85 arc(91.86,116.8) 92.35,116.78 100.67,116.78 115.95,117.22 arc(116,117.22) 116.06,117.22 127.57,116.56 arc(127.71,116.55) 127.85,116.55 133.19,116.55 arc(133.71,116.58) 134.22,116.69 136.03,117.19 arc(136.09,117.21) 136.16,117.24 136.34,117.32 arc(136.39,117.34) 136.44,117.37 137.25,117.88 arc(137.43,117.96) 137.62,117.98 149.88,117.98 arc(150.12,117.94) 150.32,117.8 150.53,117.59 arc(150.64,117.42) 150.68,117.22 150.68,117.01 arc(150.62,116.84) v1(150.46,116.78)
PCIE4_CLK_P: length 88.1
  TOP w0.114: v1(151.17,116.78) 150.94,117.01 150.94,117.51 151.06,117.64 SSD2.55 ; v3(70.52,124.5) 70.36,124.34 70.36,123.98 70.48,123.86 J1.E23
  BOTTOM w0.114: v3(70.52,124.5) 70.38,124.36 70.38,124.17 70.49,124.05 81.03,124.05 82.41,122.67 83.49,122.17 84.63,121.04 85.09,120.78 85.46,120.42 arc(85.54,120.29) 85.57,120.13 85.57,119.82 arc(85.65,119.44) 85.87,119.12 86.55,118.43 arc(87.32,117.87) 88.23,117.58 91.41,117.11 arc(91.88,117.05) 92.35,117.04 100.67,117.04 115.94,117.48 arc(116.01,117.48) 116.08,117.48 127.58,116.81 arc(127.71,116.8) 127.85,116.8 133.19,116.8 arc(133.68,116.83) 134.16,116.93 135.95,117.43 arc(136,117.45) 136.06,117.47 136.24,117.55 arc(136.27,117.57) 136.31,117.59 137.12,118.09 arc(137.36,118.2) 137.62,118.24 149.88,118.24 arc(150.22,118.17) 150.5,117.98 150.71,117.77 arc(150.88,117.52) 150.94,117.22 150.94,117.01 arc(151.01,116.84) v1(151.17,116.78)
PCIE4_CLKREQ_N: length 110.1
  TOP w0.107: SSD2.52 150.31,112.86 150.01,113.16 v1(150.01,113.67) ; v1(56.24,127.46) 56,127.22 J1.G8
  BOTTOM w0.107: v1(56.24,127.46) 55.58,126.8 55.58,123.95 55.71,123.82 55.71,121.19 56.79,120.11 56.79,118.03 57.76,117.07 73.59,113.7 78.16,113.7 79.39,113.39 79.45,113.36 85.7,110.91 96.64,110.91 98.45,109.1 104.4,109.1 106.64,111.34 133.13,111.34 135.54,110.23 137.24,110.27 137.62,110.27 138.52,110.29 140.4,111.87 144.47,113.21 149.56,113.21 v1(150.01,113.67)
PCIE4_RST_N: length 113.8
  TOP w0.107: SSD2.50 149.81,112.72 149.39,113.14 v1(149.39,114.29) ; J1.J9 v1(56.9,130.52)
  BOTTOM w0.107: v1(56.9,130.52) 57.57,130.52 58.14,129.95 58.14,128.75 56.95,127.56 56.95,127.25 56.49,126.79 56.49,124.49 56.59,124.39 56.59,120.89 57.86,119.62 57.86,117.98 58.52,117.32 73.63,114.11 78.27,114.11 79.42,113.82 85.78,111.32 99.94,111.32 100.37,111.75 133.24,111.75 135.65,110.65 137.24,110.68 137.62,110.68 138.37,110.7 140.2,112.23 144.46,113.64 148.74,113.64 v1(149.39,114.29) R760.1
PCIE5_CLK_N: length 30.1
  TOP w0.114: J1.F25 72.53,125.36 72.39,125.5 72.39,125.87 v3(72.52,126)
  IN1 w0.122: v3(72.52,126) 72.39,126.12 72.39,126.37 72.51,126.49 73.15,126.49 73.89,125.75 73.89,122.86 72.72,121.7 72.72,120.9 73.46,120.16 73.46,119.56 72.44,118.55 72.44,116.15 75.16,113.43 75.16,111.33 75.62,110.87 77.15,110.87 77.42,111.14 77.42,111.51 v1(77.65,111.73)
  BOTTOM w0.114: v1(77.65,111.73) 77.42,111.51 77.42,106.2 77.15,105.94 76.83,105.94 RZ181.2
PCIE5_CLK_P: length 30.2
  TOP w0.114: J1.F24 71.99,125.36 72.14,125.5 72.14,125.84 v3(71.98,126)
  IN1 w0.122: v1(76.94,111.73) 77.17,111.51 77.17,111.25 77.04,111.12 75.72,111.12 75.41,111.43 75.41,113.54 72.69,116.26 72.69,118.44 73.71,119.46 73.71,120.27 72.97,121.01 72.97,121.59 74.14,122.76 74.14,125.86 73.25,126.75 72.41,126.75 72.14,126.48 72.14,126.15 v3(71.98,126)
  BOTTOM w0.114: RZ179.2 76.43,106.58 76.82,106.19 77.05,106.19 77.17,106.31 77.17,108.44 77.03,108.58 77.03,108.92 77.17,109.06 77.17,109.4 77.03,109.54 77.03,109.88 77.17,110.02 77.17,110.36 77.03,110.5 77.03,110.84 77.17,110.98 77.17,111.51 v1(76.94,111.73)
PCIE5_CLKREQ_N: length 28.2
  TOP w0.107: RZU21.2 73.96,109.75 R565.2 73.96,113.97 72.49,115.44 57.02,115.44 55.55,116.92 55.55,118.75 55.75,118.95 55.75,120.32 56,120.57 J1.C8
PCIE5_RST_N: length 163.1
  TOP w0.107: RZ81.2 v1(64.85,68.2) ; v1(49.81,106.17) 48.59,106.17 47.22,107.54 R560.2 47.22,110.21 47.54,110.53 U3.4
  IN1 w0.124: v1(73.79,35.31) 73.1,35.99 68.4,35.99 67,34.59 56.21,34.59 v1(55.5,35.31) 54.82,35.99 51.51,35.99 50.11,34.59 37.92,34.59 v1(37.21,35.31) 36.02,36.5 31.04,36.5 30.02,37.51 20.7,37.51 20.45,37.77 v1(20.45,38.23)
  IN3 w0.124: v1(49.81,106.17) 50.34,105.64 50.34,100.88 51.05,100.18 51.05,92.99 50.46,92.4 50.46,87.4 49.23,86.16 47.22,86.16 46.5,85.45 46.5,77.86 47.88,76.48 47.88,75.54 49.12,74.3 61.7,74.3 64.85,71.15 v1(64.85,68.2)
  BOTTOM w0.107: U43.17 37.58,34.94 v1(37.21,35.31) ; U41.17 20.81,37.86 v1(20.45,38.23) ; RZ180.2 v1(49.81,106.17) ; v1(73.79,35.31) 74.15,34.94 U47.17 ; U45.17 55.86,34.94 v1(55.5,35.31) 55.14,35.66 55.14,46.86 55.98,47.7 55.98,51.33 57.45,52.81 57.45,54.99 58.85,56.39 58.85,63.7 59.61,64.47 61.11,64.47 v1(64.85,68.2)
PCIE5_RST_N1: length 163.1
  TOP w0.107: U5.4 v1(50.58,109.72)
  IN1 w0.124: v1(50.58,109.72) 50.58,106 49.72,105.13 49.72,100.21 50.1,99.83 50.1,94.38 49.39,93.67 49.39,81.24 50.01,80.61 50.01,77.55 50.55,77.01 50.55,73.33 51.7,72.17 58.94,72.17 59.39,71.73 59.39,70.56 60.94,69 60.94,61.91 64.76,58.09 72.24,58.09 v1(72.34,57.99)
  IN3 w0.124: v1(92.08,35.31) 95.99,35.31 96.56,35.87 108.05,35.87 109.12,34.8 109.86,34.8 v1(110.36,35.31) 111.18,36.12 121.62,36.12 123.19,34.54 127.56,34.54 128.4,35.38 v1(128.4,35.61) 128.4,36.2 127.51,37.08 127.51,42.93 v1(125.73,44.7)
  BOTTOM w0.107: U55.17 126.09,45.07 v1(125.73,44.7) ; U49.17 92.44,34.94 v1(92.08,35.31) 92.08,35.33 91.77,35.64 91.77,38.4 91.49,38.68 89.23,38.68 86.15,41.77 74.96,41.77 74.27,42.45 74.27,46.69 72.34,48.62 v1(72.34,57.99) ; U53.17 129.02,35.32 128.73,35.61 v1(128.4,35.61) ; v1(110.36,35.31) 110.73,34.94 U51.17
PCIE5RST_N: length 26.4
  TOP w0.107: 51.08,112.78 U5.2 ; 51.08,112.78 50.96,112.89 48.83,112.89 48.71,112.78 ; 51.08,112.78 51.2,112.89 v1(51.58,112.89) U5.1 ; v1(57.68,129.01) 58,128.69 J1.H10 ; U3.2 48.21,112.77 48.34,112.89 48.59,112.89 48.71,112.78 ; 48.71,112.78 U3.1
  BOTTOM w0.107: v1(51.58,112.89) 51.58,113.91 52.86,115.19 52.86,118.92 53.26,119.33 53.26,125.2 56.34,128.27 56.95,128.27 v1(57.68,129.01)
PCIE_3V3_EN: length 110.2
  TOP w0.107: J1.L48 94.8,136.14 92.53,138.4 75.41,138.4 74.24,137.24 52.25,137.24 v1(52.07,137.41) ; RZU25.1 v1(38.3,101.3) ; RZU27.1 v1(38.3,91.64)
  BOTTOM w0.107: R661.2 RZ194.2 38.02,87.27 38.3,87.55 v1(38.3,91.64) 37.54,92.41 37.54,100.53 v1(38.3,101.3) 37.41,102.18 37.41,118.19 38.61,119.38 38.61,128.27 43.26,132.92 45.8,132.92 50.29,137.41 v1(52.07,137.41)
PCIE_RST#: length 41.7
  TOP w0.107: v1(114.58,101.47) 114.58,107.06 115.43,107.91 U89.6 ; RZ67.1 v1(126.24,78.49)
  BOTTOM w0.107: v1(114.58,101.47) 114.3,101.19 114.3,80.24 115.11,79.43 125.53,79.43 126.24,78.71 v1(126.24,78.49)
PCIE_RXN1: length 79.3
  IN1 w0.122: v1(64.99,84.12) 64.99,83.99 64.82,83.82 64.51,83.82 64.39,83.94 64.39,85.22 64.74,85.56 64.92,85.56 65.19,85.83 65.19,86.02 65.46,86.29 65.64,86.29 65.91,86.56 65.91,86.74 66.88,87.71 66.88,87.93 v3(67.16,88.22)
  BOTTOM w0.114: CM82.2 22.43,40.22 22.43,40.77 22.91,41.25 23.76,41.25 26.49,43.97 31.58,43.97 34.21,46.61 34.21,55.52 40.03,61.34 40.03,63.17 42.69,65.84 47.67,65.84 48.59,66.76 48.59,69.34 53.82,74.57 60,74.57 61.58,76.16 61.58,76.77 63.75,78.94 63.75,83.19 64.46,83.9 64.76,83.9 v1(64.99,84.12) ; U67.V23 v3(67.16,88.22)
PCIE_RXN2: length 67.6
  IN1 w0.122: v1(67.88,74.93) 67.65,74.7 67.44,74.7 66.7,75.44 66.7,76.59 66.83,76.72 66.83,77.1 66.7,77.23 66.7,77.61 66.83,77.74 66.83,78.12 66.7,78.25 66.7,80.67 66.95,80.92 66.95,82.07 68.28,83.39 68.28,83.88 68.4,84.01 68.4,84.39 68.28,84.52 68.28,84.9 68.4,85.03 68.4,85.41 68.28,85.54 68.28,85.92 68.63,86.28 68.63,86.9 68.5,87.02 68.5,87.16 v3(68.76,87.42)
  BOTTOM w0.114: CM94.2 39.19,37.55 39.19,40.94 42.16,43.92 42.16,48.59 47.14,53.57 47.14,56.8 47.8,57.46 47.8,58.75 58.75,69.7 60.25,69.7 65.25,74.7 67.65,74.7 v1(67.88,74.93) ; U67.Y24 v3(68.76,87.42)
PCIE_RXN3: length 64.6
  IN1 w0.122: v1(68.48,71.12) 68.71,71.35 68.71,72.18 68.5,72.39 67.67,72.39 65.61,74.45 65.61,79.96 60.55,85.01 60.55,86.59 61.01,87.05 61.01,87.17 v3(60.76,87.42)
  BOTTOM w0.114: v1(68.48,71.12) 68.71,70.89 68.71,70.18 68.12,69.6 66.85,69.6 66.17,68.91 66.17,67.01 65.56,66.4 64.11,66.4 63.07,65.36 63.07,62.56 62.31,61.8 62.31,58.78 58.29,54.76 58.29,48.7 56.9,47.3 56.9,46.74 arc(56.81,46.55) 56.62,46.47 56.42,46.47 arc(56.06,46.31) 55.91,45.95 55.91,45.11 arc(56.06,44.73) 56.44,44.57 56.62,44.57 arc(56.82,44.49) 56.9,44.3 56.9,43.47 arc(56.81,43.27) 56.62,43.19 56.41,43.19 arc(56.05,43.04) 55.91,42.68 55.91,41.83 arc(56.06,41.45) 56.44,41.3 56.62,41.3 arc(56.81,41.21) 56.9,41.02 56.9,39.75 57.47,39.17 57.47,37.55 CM92.2 ; v3(60.76,87.42) 61.16,87.82 U67.L24
PCIE_RXN4: length 65.5
  IN1 w0.122: v1(69.45,65.02) 69.68,65.25 69.68,65.54 69.56,65.66 67.59,65.66 66.5,66.75 66.5,71.35 62.43,75.41 62.43,77.59 60.33,79.7 60.33,82.57 57.71,85.19 57.71,86.92 57.81,87.02 57.81,87.17 v3(57.56,87.42)
  BOTTOM w0.114: v1(69.45,65.02) 69.68,64.8 69.68,61.49 69.19,61 69.19,56.84 arc(69.13,56.69) 68.99,56.63 68.29,56.63 arc(67.97,56.5) 67.84,56.19 67.84,55.18 arc(67.97,54.87) 68.29,54.74 68.96,54.74 arc(69.12,54.67) 69.19,54.51 69.19,53.58 arc(69.12,53.42) 68.96,53.36 68.39,53.36 arc(68.02,53.2) 67.87,52.83 67.87,51.97 arc(68.02,51.61) 68.37,51.46 68.96,51.46 arc(69.12,51.4) 69.19,51.23 69.19,47.29 69.93,46.55 69.93,41.77 73.23,38.48 75.03,38.48 75.76,37.75 75.76,37.55 CM90.2 ; U67.G24 57.96,87.82 v3(57.56,87.42)
PCIE_RXN5: length 80.2
  IN1 w0.122: v1(73.18,61.38) 73.41,61.61 73.41,62.33 72.36,63.37 67.61,63.37 65.71,65.26 65.71,71.02 61.65,75.09 61.65,77.23 59.54,79.34 59.54,82.21 57.04,84.71 55.5,84.71 54.36,85.85 54.36,87.25 54.74,87.63 56.03,87.63 56.23,87.84 56.23,87.94 v3(55.96,88.22)
  BOTTOM w0.114: v1(73.18,61.38) 73.41,61.15 73.41,56.92 74.93,55.4 85.95,55.4 90.65,50.69 90.65,42.46 94.05,39.07 94.05,37.55 CM88.2 ; v3(55.96,88.22) 56.36,88.62 U67.E23
PCIE_RXN6: length 69.5
  TOP w0.114: v1(57.57,50.97) 57.34,51.19 57.34,51.4 RZ107.2
  IN1 w0.122: v1(57.57,50.97) 57.34,50.74 57.34,45.05 60.45,41.94 72.78,41.94 73.95,40.77 78.03,40.77 78.79,41.53 86.75,41.53 89,39.27 94.97,39.27 95.1,39.4 95.48,39.4 95.61,39.27 95.99,39.27 96.12,39.4 96.5,39.4 96.63,39.27 97.01,39.27 97.14,39.4 97.52,39.4 97.65,39.27 98.87,39.27 100.38,37.76 102.34,37.76 102.47,37.89 102.85,37.89 102.98,37.76 103.36,37.76 103.49,37.89 103.87,37.89 104,37.76 105.12,37.76 105.76,38.41 108.43,38.41 108.56,38.54 108.94,38.54 109.07,38.41 109.45,38.41 109.58,38.54 109.96,38.54 110.09,38.41 110.47,38.41 110.6,38.54 110.99,38.54 111.11,38.41 112.22,38.41 112.34,38.53 112.34,38.7 v1(112.11,38.93)
  BOTTOM w0.114: v1(112.11,38.93) 112.34,38.7 112.34,37.55 CM86.2
PCIE_RXN7: length 95.8
  TOP w0.114: v1(53.89,54.01) 53.66,54.24 53.66,54.44 RZ102.2
  IN1 w0.122: v1(130.4,38.37) 130.63,38.14 130.63,37 130.45,36.83 129.73,36.83 129.6,36.96 129.22,36.96 129.09,36.83 128.71,36.83 128.58,36.96 128.2,36.96 128.07,36.83 127.69,36.83 127.56,36.96 127.18,36.96 127.05,36.83 122.96,36.83 122.27,36.14 121.33,36.14 121.2,36.27 120.82,36.27 120.69,36.14 120.3,36.14 120.18,36.27 119.79,36.27 119.66,36.14 119.28,36.14 119.15,36.27 118.77,36.27 118.64,36.14 115.29,36.14 113.69,34.54 112.82,34.54 112.69,34.67 112.31,34.67 112.18,34.54 111.8,34.54 111.67,34.67 111.29,34.67 111.16,34.54 87.21,34.54 84.04,37.72 80.97,37.72 80.28,38.41 60.54,38.41 53.66,45.3 53.66,53.78 v1(53.89,54.01)
  BOTTOM w0.114: CM84.2 130.63,37.93 130.63,38.14 v1(130.4,38.37)
PCIE_RXN8: length 96.1
  TOP w0.114: RZ97.2 39.46,61.53 38.87,61.53 v1(38.65,61.3)
  IN1 w0.122: v1(38.65,61.3) 38.87,61.53 39.07,61.53 39.14,61.46 39.14,60.7 39.79,60.05 42.27,60.05 43.49,58.83 48.35,58.83 48.62,59.1 50.53,59.1 51.71,57.91 58.21,57.91 60.88,55.24 66.26,55.24 71.85,49.66 76.38,49.66 77.92,48.12 85.99,48.12 87.81,49.94 90.93,49.94 94.32,46.55 106.89,46.55 107.21,46.23 121.88,46.23 122.2,46.55 123.07,46.55 v1(123.3,46.32)
  BOTTOM w0.114: CM80.2 123.74,46.55 123.53,46.55 v1(123.3,46.32)
PCIE_RXP1: length 79.3
  IN1 w0.122: v1(64.99,83.41) 64.83,83.57 64.41,83.57 64.14,83.84 64.14,85.32 66.62,87.81 66.62,87.95 v3(66.36,88.22)
  BOTTOM w0.114: U67.U23 v3(66.36,88.22) ; CM81.2 22.68,40.22 22.68,40.67 23.01,41 23.87,41 26.59,43.72 31.68,43.72 34.47,46.5 34.47,55.42 40.28,61.24 40.28,63.07 42.8,65.58 47.78,65.58 48.84,66.65 48.84,69.24 53.93,74.32 60.1,74.32 60.79,75.01 60.99,75.01 61.24,75.26 61.24,75.45 61.84,76.05 61.84,76.67 62.48,77.31 62.67,77.31 62.93,77.56 62.93,77.76 63.18,78.01 63.37,78.01 63.62,78.26 63.62,78.45 64.01,78.84 64.01,83.08 64.57,83.64 64.76,83.64 v1(64.99,83.41)
PCIE_RXP2: length 67.6
  IN1 w0.122: v1(67.88,74.22) 67.65,74.45 67.33,74.45 66.45,75.33 66.45,80.77 66.7,81.03 66.7,82.17 68.02,83.49 68.02,86.03 68.38,86.39 68.38,86.79 68.25,86.92 68.25,87.13 v3(67.96,87.42)
  BOTTOM w0.114: CM93.2 39.44,37.56 39.44,40.84 42.42,43.81 42.42,48.49 47.4,53.46 47.4,56.69 48.06,57.35 48.06,58.64 57.3,67.89 57.49,67.89 57.74,68.14 57.74,68.33 58,68.58 58.19,68.58 58.44,68.84 58.44,69.03 58.86,69.44 60.35,69.44 63.77,72.87 63.97,72.87 64.22,73.12 64.22,73.31 64.47,73.56 64.67,73.56 64.92,73.82 64.92,74.01 65.35,74.45 67.65,74.45 v1(67.88,74.22) ; U67.W24 v3(67.96,87.42)
PCIE_RXP3: length 64.6
  IN1 w0.122: v1(69.19,71.12) 68.96,71.35 68.96,72.29 68.61,72.64 67.77,72.64 65.86,74.55 65.86,80.06 60.81,85.12 60.81,86.49 61.26,86.94 61.26,87.12 v3(61.56,87.42)
  BOTTOM w0.114: CM91.2 57.73,37.56 57.73,39.28 57.15,39.86 57.15,41.02 arc(56.99,41.39) 56.62,41.55 56.44,41.55 arc(56.24,41.63) 56.16,41.83 56.16,42.68 arc(56.23,42.86) 56.41,42.93 56.62,42.93 arc(56.99,43.09) 57.15,43.47 57.15,44.3 arc(56.99,44.67) 56.62,44.83 56.44,44.83 arc(56.24,44.91) 56.16,45.11 56.16,45.95 arc(56.24,46.13) 56.42,46.21 56.62,46.21 arc(56.99,46.37) 57.15,46.74 57.15,47.19 58.55,48.59 58.55,54.66 62.56,58.67 62.56,61.69 63.32,62.45 63.32,65.25 64.21,66.14 65.66,66.14 66.42,66.9 66.42,68.8 66.96,69.34 68.22,69.34 68.96,70.08 68.96,70.89 v1(69.19,71.12) ; v3(61.56,87.42) 61.96,87.82 U67.M24
PCIE_RXP4: length 65.6
  IN1 w0.122: v3(58.36,87.42) 58.06,87.12 58.06,86.92 57.96,86.82 57.96,85.29 60.58,82.68 60.58,79.81 62.69,77.7 62.69,75.52 66.75,71.45 66.75,66.85 67.69,65.91 69.66,65.91 69.93,65.64 69.93,65.25 v1(70.16,65.02)
  BOTTOM w0.114: v3(58.36,87.42) 58.76,87.82 U67.H24 ; v1(70.16,65.02) 69.93,64.8 69.93,61.39 69.44,60.9 69.44,56.84 arc(69.31,56.51) 68.99,56.38 68.29,56.38 arc(68.15,56.32) 68.1,56.19 68.1,55.18 arc(68.15,55.05) 68.29,54.99 68.96,54.99 arc(69.3,54.85) 69.44,54.51 69.44,53.58 arc(69.3,53.24) 68.96,53.1 68.39,53.1 arc(68.2,53.02) 68.12,52.83 68.12,51.97 arc(68.2,51.79) 68.37,51.72 68.96,51.72 arc(69.3,51.58) 69.44,51.23 69.44,47.4 70.19,46.66 70.19,41.88 73.33,38.73 75.13,38.73 76.02,37.85 76.02,37.56 CM89.2
PCIE_RXP5: length 80.2
  IN1 w0.122: v1(73.89,61.38) 73.66,61.61 73.66,62.43 72.47,63.63 67.71,63.63 65.97,65.37 65.97,71.13 61.9,75.19 61.9,77.34 59.8,79.45 59.8,82.32 57.15,84.96 55.6,84.96 54.61,85.96 54.61,87.14 54.84,87.38 56.13,87.38 56.49,87.73 56.49,87.94 v3(56.76,88.22)
  BOTTOM w0.114: CM87.2 94.3,37.56 94.3,39.17 90.91,42.57 90.91,50.8 86.05,55.65 75.04,55.65 73.66,57.03 73.66,61.15 v1(73.89,61.38) ; U67.F23 57.16,88.62 v3(56.76,88.22)
PCIE_RXP6: length 69.5
  TOP w0.114: v1(56.86,50.97) 57.09,51.19 57.09,51.4 RZ106.2
  IN1 w0.122: v1(56.86,50.97) 57.09,50.74 57.09,44.94 60.35,41.68 72.68,41.68 73.84,40.52 78.14,40.52 78.89,41.27 86.64,41.27 88.9,39.02 98.76,39.02 100.27,37.51 105.23,37.51 105.87,38.15 112.32,38.15 112.59,38.42 112.59,38.7 v1(112.82,38.93)
  BOTTOM w0.114: CM85.2 112.59,37.56 112.59,38.7 v1(112.82,38.93)
PCIE_RXP7: length 95.8
  TOP w0.114: v1(53.17,54.01) 53.4,54.24 53.4,54.44 RZ101.2
  IN1 w0.122: v1(131.11,38.37) 130.88,38.14 130.88,36.9 130.56,36.58 123.06,36.58 122.38,35.89 115.39,35.89 113.79,34.29 87.11,34.29 83.93,37.47 80.87,37.47 80.17,38.16 60.44,38.16 53.4,45.2 53.4,53.78 v1(53.17,54.01)
  BOTTOM w0.114: CM83.2 130.88,37.94 130.88,38.14 v1(131.11,38.37)
PCIE_RXP8: length 96.1
  TOP w0.114: RZ96.2 39.46,61.79 38.87,61.79 v1(38.65,62.01)
  IN1 w0.122: v1(38.65,62.01) 38.87,61.79 39.18,61.79 39.4,61.57 39.4,60.8 39.9,60.3 42.38,60.3 43.6,59.08 48.25,59.08 48.52,59.35 50.64,59.35 51.82,58.17 58.32,58.17 60.99,55.5 66.37,55.5 71.95,49.91 76.48,49.91 78.02,48.37 85.89,48.37 87.71,50.19 91.04,50.19 94.42,46.81 107,46.81 107.32,46.48 121.77,46.48 122.09,46.81 123.07,46.81 v1(123.3,47.03)
  BOTTOM w0.114: CM79.2 123.73,46.81 123.53,46.81 v1(123.3,47.03)
PCIE_TXN1: length 75.4
  TOP w0.114: v1(66.19,81.92) 65.96,82.14 65.96,82.47 66.93,83.44 66.93,83.73 CM47.2
  BOTTOM w0.114: v1(66.19,81.92) 65.96,82.14 65.96,82.41 65.7,82.68 65.15,82.68 64.77,82.3 64.77,78.31 62.59,76.13 62.59,75.51 59.84,72.77 56.56,72.77 55.85,72.06 55.85,71.12 54.73,70 51.66,70 50.77,69.12 50.77,67.09 48.23,64.54 45.03,64.54 35.36,54.87 35.36,46.2 32.13,42.97 26.9,42.97 23.91,39.98 23.91,37.9 23.81,37.81 U41.23
PCIE_TXN2: length 64.9
  IN1 w0.122: v1(68.3,81.98) 68.07,81.75 68.07,80.52 68.66,79.93 68.66,78.91 68.79,78.78 68.79,78.4 68.66,78.27 68.66,77.89 68.79,77.76 68.79,77.38 68.66,77.25 68.66,76.87 68.79,76.74 68.79,76.35 68.66,76.23 68.66,74.72 68.78,74.6 69.14,74.6 69.33,74.79 v1(69.33,74.9)
  BOTTOM w0.114: v1(68.3,81.98) 68.07,82.21 68.07,82.46 CM77.2 ; U43.23 40.58,34.86 40.67,34.96 40.67,40.93 43.23,43.48 43.23,48.18 49.94,54.89 49.94,59.36 51.43,60.86 51.69,60.86 58.98,68.15 60.27,68.15 62.15,70.03 63.4,70.03 66.52,73.15 68.07,73.15 68.61,73.69 68.61,74.45 68.83,74.68 69.1,74.68 v1(69.33,74.9)
PCIE_TXN3: length 63.6
  IN1 w0.122: v1(67.72,67.44) 67.94,67.67 67.94,69.13 67.39,69.69 67.39,71.57 67.35,71.61 67.34,71.61 64.72,74.23 64.72,76.71 61.47,79.96 61.47,81.88 v1(61.24,82.11)
  BOTTOM w0.114: v1(67.72,67.44) 67.94,67.21 67.94,66.6 66.65,65.3 64.67,65.3 arc(64.29,65.15) 64.14,64.77 64.14,63.96 arc(64.29,63.57) 64.68,63.41 67.14,63.41 arc(67.3,63.35) 67.36,63.2 67.36,62.28 arc(67.29,62.1) 67.11,62.03 64.14,62.03 63.51,61.4 63.51,58.44 59.3,54.22 59.3,48.28 57.91,46.9 57.91,40.39 58.8,39.5 58.8,35.58 58.99,35.4 58.99,34.98 58.86,34.86 U45.23 ; v1(61.24,82.11) 61.47,82.33 61.47,82.59 CM74.2
PCIE_TXN4: length 61.9
  IN1 w0.122: v1(70.64,61.34) 70.87,61.57 70.87,62.18 70.56,62.48 66.9,62.48 63.96,65.43 63.96,68.88 arc(64.09,69.21) 64.42,69.35 64.6,69.35 arc(64.83,69.44) 64.92,69.67 64.92,70.13 arc(64.86,70.29) 64.7,70.36 64.44,70.36 arc(64.1,70.5) 63.96,70.84 63.96,71.67 58.76,76.87 58.76,80.74 58.24,81.25 58.24,81.88 v1(58.01,82.11)
  BOTTOM w0.114: U47.23 77.15,34.86 77.27,34.98 77.27,35.4 77.09,35.58 77.09,37.97 75.57,39.5 73.75,39.5 70.98,42.27 70.98,47 70.31,47.68 70.31,60.22 70.87,60.78 70.87,61.11 v1(70.64,61.34) ; v1(58.01,82.11) 58.24,82.33 58.24,82.59 CM76.2
PCIE_TXN5: length 75.6
  TOP w0.114: v1(55.83,82.11) 56.06,82.33 56.06,82.59 CM48.2
  IN1 w0.122: v1(74.32,59.18) 74.55,59.41 74.55,60.09 74.19,60.45 70,60.45 68.98,61.47 66.55,61.47 66.29,61.72 63.07,64.95 63.07,69.34 61.87,70.53 61.87,72.65 57.98,76.55 57.98,80.4 57.53,80.85 56.4,80.85 56.06,81.19 56.06,81.88 v1(55.83,82.11)
  BOTTOM w0.114: v1(74.32,59.18) 74.55,58.95 74.55,58.57 75.97,57.15 82.45,57.15 83.19,56.41 86.4,56.41 91.69,51.12 91.69,42.92 95.38,39.24 95.38,35.3 95.56,35.12 95.56,34.98 95.44,34.86 U49.23
PCIE_TXN6: length 76.6
  TOP w0.114: CM61.2 56.12,54.51 56.12,54.25 v1(56.35,54.03)
  IN1 w0.122: v1(56.35,54.03) 56.12,53.8 56.12,50.25 56.44,49.94 56.44,44.76 60.04,41.15 72.35,41.15 73.53,39.98 84.79,39.98 84.92,40.11 85.3,40.11 85.43,39.98 85.81,39.98 85.94,40.11 86.32,40.11 86.45,39.98 87.19,39.98 88.86,38.31 95.15,38.31 95.28,38.44 95.66,38.44 95.79,38.31 96.17,38.31 96.3,38.44 96.68,38.44 96.81,38.31 97.19,38.31 97.32,38.44 97.7,38.44 97.83,38.31 98.72,38.31 100.05,36.98 109.98,36.98 110.11,37.11 110.49,37.11 110.62,36.98 111,36.98 111.13,37.11 111.51,37.11 111.64,36.98 112.02,36.98 112.15,37.11 112.53,37.11 112.66,36.98 113.44,36.98 113.67,37.21 113.67,37.74 v1(113.44,37.97)
  BOTTOM w0.114: U51.23 113.73,34.86 113.85,34.98 113.85,35.14 113.67,35.33 113.67,37.74 v1(113.44,37.97)
PCIE_TXN7: length 96.4
  TOP w0.114: CM63.2 54.85,51.46 54.85,51.21 v1(55.08,50.98)
  IN1 w0.122: v1(131.72,40.27) 131.95,40.05 131.95,39.87 131.83,39.75 129.28,39.75 129.15,39.88 128.77,39.88 128.64,39.75 128.25,39.75 128.13,39.88 127.74,39.88 127.61,39.75 127.23,39.75 127.1,39.88 126.72,39.88 126.59,39.75 124.48,39.75 121.8,37.07 121.38,37.07 121.25,37.2 120.87,37.2 120.74,37.07 120.36,37.07 120.23,37.2 119.84,37.2 119.72,37.07 119.33,37.07 119.2,37.2 118.82,37.2 118.69,37.07 114.69,37.07 113.69,36.07 112.74,36.07 112.61,36.2 112.23,36.2 112.1,36.07 111.72,36.07 111.59,36.2 111.21,36.2 111.08,36.07 87.61,36.07 85.07,38.61 81.28,38.61 80.69,39.2 73.2,39.2 72.04,40.36 59.72,40.36 55.52,44.56 55.52,49.56 54.85,50.23 54.85,50.75 v1(55.08,50.98)
  BOTTOM w0.114: U53.23 132.02,35.31 132.14,35.43 132.14,35.78 131.95,35.96 131.95,40.05 v1(131.72,40.27)
PCIE_TXN8: length 98
  TOP w0.114: v1(42.21,62.52) 42.44,62.75 43.08,62.75 CM59.2
  IN1 w0.122: v1(125.01,48.09) 124.79,48.32 121.33,48.32 120.02,47.01 107.78,47.01 107.34,47.45 94.64,47.45 91.37,50.72 87.49,50.72 85.67,48.9 78.34,48.9 76.8,50.44 72.17,50.44 66.59,56.03 61.49,56.03 58.4,59.12 58.4,60.77 58.17,61 49.42,61 48.04,59.61 43.81,59.61 42.67,60.75 42.67,62.69 42.62,62.75 42.44,62.75 v1(42.21,62.52)
  BOTTOM w0.114: v1(125.01,48.09) 125.24,48.32 125.57,48.32 125.69,48.19 125.98,48.19 126.11,48.07 U55.23
PCIE_TXP1: length 75.4
  TOP w0.114: v1(65.48,81.92) 65.71,82.14 65.71,82.58 66.67,83.54 66.67,83.73 CM46.2
  BOTTOM w0.114: U41.24 24.31,37.79 24.16,37.94 24.16,39.87 27.01,42.72 32.23,42.72 35.61,46.1 35.61,54.76 45.14,64.29 48.34,64.29 51.03,66.98 51.03,69.01 51.77,69.75 54.84,69.75 56.11,71.02 56.11,71.96 56.67,72.52 58.49,72.52 58.62,72.38 58.98,72.38 59.12,72.52 59.95,72.52 61.45,74.01 61.64,74.01 61.89,74.27 61.89,74.46 62.14,74.71 62.34,74.71 62.59,74.96 62.59,75.16 62.84,75.41 62.84,76.02 63.61,76.79 63.8,76.79 64.05,77.04 64.05,77.24 64.31,77.49 64.5,77.49 64.75,77.74 64.75,77.93 65.02,78.21 65.02,78.94 65.16,79.08 65.16,79.43 65.02,79.57 65.02,79.92 65.16,80.06 65.16,80.42 65.02,80.55 65.02,82.19 65.26,82.42 65.6,82.42 65.71,82.31 65.71,82.14 v1(65.48,81.92)
