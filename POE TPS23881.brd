# Allegro board POE TPS23881.brd (continued)
## Text on the board (continued)
User.34: NOTES: | - MNC_LAYER: MUST-NOT-CUT-LAYER | - MAX_DEPTH: DEPTH FROM START LAYER TO THE | SURFACE OF MUST-NOT-CUT-LAYER | - MFG_STUB : MANUFACTURING STUB LENGTH | FIGURE | BD_SIZE | 8.0 | 10.0 | MNC_LAYER | IN3 | BACKDRILL: BOTTOM to GND2 | ALL UNITS ARE IN MILS | MAX_DEPTH | 9.35 | MFG_STUB | - | QTY | 4 | TOTAL BACKDRILLS: 8
