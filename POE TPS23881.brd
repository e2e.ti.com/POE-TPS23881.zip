# Allegro board POE TPS23881.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
CB130  0.1U/6.3V/X5R-C1  [SM0201_C]  55.5 25.53 90 top
CB131  0.1U/6.3V/X5R-C1  [SM0201_C]  73.79 25.53 90 top
CB132  0.1U/6.3V/X5R-C1  [SM0201_C]  92.08 25.53 90 top
CB133  0.1U/6.3V/X5R-C1  [SM0201_C]  110.36 25.53 90 top
CB134  0.1U/6.3V/X5R-C1  [SM0201_C]  138.68 177.32 180 bottom
CB135  0.1U/6.3V/X5R-C1  [SM0201_C]  127.89 143.23 90 bottom
CB136  0.1U/6.3V/X5R-C1  [SM0201_C]  143.89 93.22 270 bottom
CB137  0.1U/6.3V/X5R-C1  [SM0201_C]  108.97 88.14 270 bottom
CB138  0.1U/6.3V/X5R-C1  [SM0201_C]  111.66 83.31 180 bottom
CB139  0.1U/6.3V/X5R-C1  [SM0201_C]  131.34 55.12 90 bottom
CB140  0.1U/6.3V/X5R-C1  [SM0201_C]  127.25 42.16 180 bottom
CB141  0.1U/6.3V/X5R-C1  [SM0201_C]  17.91 36.7 90 bottom
CB142  0.1U/6.3V/X5R-C1  [SM0201_C]  126.11 34.16 90 bottom
CB143  0.1U/6.3V/X5R-C1  [SM0201_C]  107.82 33.78 90 bottom
CB144  0.1U/6.3V/X5R-C1  [SM0201_C]  89.53 33.78 90 bottom
CB145  0.1U/6.3V/X5R-C1  [SM0201_C]  71.25 33.78 90 bottom
CB146  0.1U/6.3V/X5R-C1  [SM0201_C]  52.96 33.78 90 bottom
CB147  0.1U/6.3V/X5R-C1  [SM0201_C]  34.67 33.78 90 bottom
CB148  0.1U/6.3V/X5R-C1  [SM0201_C]  31.24 32.49 0 bottom
CB149  0.1U/6.3V/X5R-C1  [SM0201_C]  139.06 30.1 0 bottom
CB150  0.1U/6.3V/X5R-C1  [SM0201_C]  120.78 29.72 0 bottom
CB151  0.1U/6.3V/X5R-C1  [SM0201_C]  102.49 29.72 0 bottom
CB152  0.1U/6.3V/X5R-C1  [SM0201_C]  84.2 29.72 0 bottom
CB153  0.1U/6.3V/X5R-C1  [SM0201_C]  65.91 29.72 0 bottom
CB154  0.1U/6.3V/X5R-C1  [SM0201_C]  47.62 29.72 0 bottom
CB155  0.1U/6.3V/X5R-C1  [SM0201_C]  99.62 91.95 90 top
CB156  0.1U/6.3V/X5R-C1  [SM0201_C]  98.98 91.95 90 top
CB157  0.1U/6.3V/X5R-C1  [SM0201_C]  97.54 91.95 90 top
CB158  0.1U/6.3V/X5R-C1  [SM0201_C]  96.9 91.95 90 top
CB159  0.1U/6.3V/X5R-C1  [SM0201_C]  96.01 91.69 90 top
CB160  0.1U/6.3V/X5R-C1  [SM0201_C]  95.38 91.69 90 top
CB161  0.1U/6.3V/X5R-C1  [SM0201_C]  94.74 91.69 90 top
CB162  0.1U/6.3V/X5R-C1  [SM0201_C]  94.11 91.69 90 top
CE1  POS-16TQC100MYF  [SM2917_CD19]  44.48 187.96 90 top
CE2  POS-6TPE221MAP  [SM2917_CD19]  152.02 185.8 270 top
CE3  HEC-100U/80V-FVF  [SMEC103X103_165]  36.45 170.56 0 top
CE4  HEC-100U/80V-FVF  [SMEC103X103_165]  24.89 162.18 180 top
CE5  HEC-100U/80V-FVF  [SMEC103X103_165]  9.65 161.04 0 top
CE6  HEC-100U/80V-FVF  [SMEC103X103_165]  28.7 114.59 0 top
CE7  HEC-100U/80V-FVF  [SMEC103X103_165]  28.67 103.75 0 top
CE8  POS-100U/6.3V-TPE  [SM1512_CB20]  132.87 103 270 top
CE9  POS-100U/6.3V-TPE  [SM1512_CB20]  119.28 93.47 270 top
CE10  POS-6TPE220MAZB  [SM1512_CB20]  126.77 85.85 0 top
CE11  POS-6TPE220MAZB  [SM1512_CB20]  99.01 60.15 270 top
CE12  POS-6TPE220MAZB  [SM1512_CB20]  77.8 55.19 90 top
CE13  POS-6TPE220MAZB  [SM1512_CB20]  64.72 53.57 90 top
CM1  0.22U/16V/X7R-C2  [SM0402_C]  147.42 121.28 270 top
CM2  1U/10V/X5R-C2  [SM0402_C]  61.29 63.83 0 top
CM3  1U/10V/X5R-C2  [SM0402_C]  46.23 67.06 180 top
CM4  1U/10V/X5R-C2  [SM0402_C]  55.37 72.64 90 top
CM5  1U/10V/X5R-C2  [SM0402_C]  61.29 64.85 0 top
CM6  1U/10V/X5R-C2  [SM0402_C]  61.29 61.8 0 top
CM7  1U/10V/X5R-C2  [SM0402_C]  52.96 72.64 90 top
CM8  1U/10V/X5R-C2  [SM0402_C]  61.29 59.64 0 top
CM9  1U/10V/X5R-C2  [SM0402_C]  46.23 63.5 180 top
CM10  1U/10V/X5R-C2  [SM0402_C]  46.23 60.83 180 top
CM11  1U/10V/X5R-C2  [SM0402_C]  51.89 57.73 270 top
CM12  1U/10V/X5R-C2  [SM0402_C]  55.37 57.78 270 top
CM13  1U/10V/X5R-C2  [SM0402_C]  57.78 72.64 90 top
CM14  1U/10V/X5R-C2  [SM0402_C]  51.94 72.64 90 top
CM15  1U/10V/X5R-C2  [SM0402_C]  57.78 57.78 270 top
CM16  1U/10V/X5R-C2  [SM0402_C]  52.96 57.78 270 top
CM17  1U/10V/X5R-C2  [SM0402_C]  46.23 62.23 180 top
CM18  1U/10V/X5R-C2  [SM0402_C]  61.29 60.66 0 top
CM19  1U/10V/X5R-C2  [SM0402_C]  54.15 72.64 90 top
CM20  1U/10V/X5R-C2  [SM0402_C]  61.29 62.81 0 top
CM21  1U/10V/X5R-C2  [SM0402_C]  56.57 57.78 270 top
CM22  1U/10V/X5R-C2  [SM0402_C]  56.57 72.64 90 top
CM23  1U/10V/X5R-C2  [SM0402_C]  54.1 57.78 270 top
CM24  1U/10V/X5R-C2  [SM0402_C]  46.81 71.96 180 top
CM25  0.22U/16V/X7R-C2  [SM0402_C]  137.72 120.42 0 top
CM26  0.22U/16V/X7R-C2  [SM0402_C]  137.72 121.56 0 top
CM27  0.22U/16V/X7R-C2  [SM0402_C]  142.16 120.4 0 top
CM28  0.22U/16V/X7R-C2  [SM0402_C]  142.16 121.54 0 top
CM29  0.22U/16V/X7R-C2  [SM0402_C]  146.28 121.28 270 top
CM30  0.22U/16V/X7R-C2  [SM0402_C]  150.5 121.28 270 top
CM31  0.22U/16V/X7R-C2  [SM0402_C]  151.64 121.28 270 top
CM32  0.22U/16V/X7R-C2  [SM0402_C]  53.85 112.56 90 top
CM33  0.22U/16V/X7R-C2  [SM0402_C]  54.86 112.56 90 top
CM34  0.22U/16V/X7R-C2  [SM0402_C]  56.32 112.56 90 top
CM35  0.22U/16V/X7R-C2  [SM0402_C]  57.34 112.56 90 top
CM36  0.22U/16V/X7R-C2  [SM0402_C]  58.74 112.56 90 top
CM37  0.22U/16V/X7R-C2  [SM0402_C]  59.75 112.56 90 top
CM38  0.22U/16V/X7R-C2  [SM0402_C]  61.21 112.56 90 top
CM39  0.22U/16V/X7R-C2  [SM0402_C]  62.23 112.56 90 top
CM40  0.22U/16V/X7R-C2  [SM0402_C]  55.12 109.05 90 top
CM41  0.22U/16V/X7R-C2  [SM0402_C]  56.13 109.05 90 top
CM42  0.22U/16V/X7R-C2  [SM0402_C]  59.94 108.93 90 top
CM43  0.22U/16V/X7R-C2  [SM0402_C]  60.96 108.93 90 top
CM44  0.22U/16V/X7R-C2  [SM0402_C]  91.34 99.16 180 top
CM45  0.22U/16V/X7R-C2  [SM0402_C]  101.19 94.23 180 top
CM46  0.22U/16V/X7R-C2  [SM0402_C]  66.29 84.58 270 top
CM47  0.22U/16V/X7R-C2  [SM0402_C]  67.31 84.58 270 top
CM48  0.22U/16V/X7R-C2  [SM0402_C]  55.68 83.44 270 top
CM49  0.22U/16V/X7R-C2  [SM0402_C]  56.69 83.44 270 top
CM50  0.22U/16V/X7R-C2  [SM0402_C]  53.04 77.34 90 top
CM51  0.22U/16V/X7R-C2  [SM0402_C]  54.05 77.34 90 top
CM52  0.22U/16V/X7R-C2  [SM0402_C]  55.45 77.34 90 top
CM53  0.22U/16V/X7R-C2  [SM0402_C]  56.46 77.34 90 top
CM54  0.22U/16V/X7R-C2  [SM0402_C]  54.23 75.18 90 top
CM55  0.22U/16V/X7R-C2  [SM0402_C]  55.24 75.18 90 top
CM56  0.22U/16V/X7R-C2  [SM0402_C]  56.64 75.18 90 top
CM57  0.22U/16V/X7R-C2  [SM0402_C]  57.66 75.18 90 top
CM58  0.22U/16V/X7R-C2  [SM0402_C]  43.94 63.37 180 top
CM59  0.22U/16V/X7R-C2  [SM0402_C]  43.94 62.36 180 top
CM60  0.22U/16V/X7R-C2  [SM0402_C]  55.5 55.37 270 top
CM61  0.22U/16V/X7R-C2  [SM0402_C]  56.52 55.37 270 top
CM62  0.22U/16V/X7R-C2  [SM0402_C]  54.23 52.32 270 top
CM63  0.22U/16V/X7R-C2  [SM0402_C]  55.24 52.32 270 top
CM64  0.22U/16V/X7R-C2  [SM0402_C]  140.08 179.07 0 bottom
CM65  0.22U/16V/X7R-C2  [SM0402_C]  130.94 141.48 270 bottom
CM66  0.22U/16V/X7R-C2  [SM0402_C]  138.94 121.23 90 bottom
CM67  0.22U/16V/X7R-C2  [SM0402_C]  137.92 121.23 90 bottom
CM68  0.22U/16V/X7R-C2  [SM0402_C]  58.55 109.09 90 bottom
CM69  0.22U/16V/X7R-C2  [SM0402_C]  57.53 109.09 90 bottom
CM70  0.22U/16V/X7R-C2  [SM0402_C]  63.37 109.05 90 bottom
CM71  0.22U/16V/X7R-C2  [SM0402_C]  62.36 109.05 90 bottom
CM72  0.22U/16V/X7R-C2  [SM0402_C]  140.74 100.08 180 bottom
CM73  0.22U/16V/X7R-C2  [SM0402_C]  62.1 83.44 270 bottom
CM74  0.22U/16V/X7R-C2  [SM0402_C]  61.09 83.44 270 bottom
CM75  0.22U/16V/X7R-C2  [SM0402_C]  58.88 83.44 270 bottom
CM76  0.22U/16V/X7R-C2  [SM0402_C]  57.86 83.44 270 bottom
CM77  0.22U/16V/X7R-C2  [SM0402_C]  68.45 83.31 270 bottom
CM78  0.22U/16V/X7R-C2  [SM0402_C]  67.44 83.31 270 bottom
CM79  0.22U/16V/X7R-C2  [SM0402_C]  124.59 47.19 180 bottom
CM80  0.22U/16V/X7R-C2  [SM0402_C]  124.59 46.18 180 bottom
CM81  0.22U/16V/X7R-C2  [SM0402_C]  23.06 39.37 90 bottom
CM82  0.22U/16V/X7R-C2  [SM0402_C]  22.05 39.37 90 bottom
CM83  0.22U/16V/X7R-C2  [SM0402_C]  131.27 37.08 90 bottom
CM84  0.22U/16V/X7R-C2  [SM0402_C]  130.25 37.08 90 bottom
CM85  0.22U/16V/X7R-C2  [SM0402_C]  112.98 36.7 90 bottom
CM86  0.22U/16V/X7R-C2  [SM0402_C]  111.96 36.7 90 bottom
CM87  0.22U/16V/X7R-C2  [SM0402_C]  94.69 36.7 90 bottom
CM88  0.22U/16V/X7R-C2  [SM0402_C]  93.68 36.7 90 bottom
CM89  0.22U/16V/X7R-C2  [SM0402_C]  76.4 36.7 90 bottom
CM90  0.22U/16V/X7R-C2  [SM0402_C]  75.39 36.7 90 bottom
CM91  0.22U/16V/X7R-C2  [SM0402_C]  58.12 36.7 90 bottom
CM92  0.22U/16V/X7R-C2  [SM0402_C]  57.1 36.7 90 bottom
CM93  0.22U/16V/X7R-C2  [SM0402_C]  39.83 36.7 90 bottom
CM94  0.22U/16V/X7R-C2  [SM0402_C]  38.81 36.7 90 bottom
CN1  USB3.2-9F-A-RA  [USB3A_WU3R-09]  108.03 66.61 90 bottom
CN2  USB3.1-GEN2-A  [USB31AV_UAA131C-40021]  82.35 45.68 0 bottom
CV1  1000P/2KV-C6  [SM1206_C]  26.37 13.67 270 top
CV8  1000P/2KV-C6  [SM1206_C]  151.76 42.29 90 top
D1  BAT54C  [SOT23-AAC]  74.57 142.88 90 bottom
D2  BAT54H  [SOD323]  87.53 105.92 90 top
D5  YEU25CA0505AC  [DFN10_2D5X1P05H06]  112.22 53.75 270 top
D7  YEU25CA0505AC  [DFN10_2D5X1P05H06]  105.23 66.55 270 top
D8  YEU25CA0505AC  [DFN10_2D5X1P05H06]  82.25 51.89 0 top
D9  YEU25CA0505AC  [DFN10_2D5X1P05H06]  90.17 191.64 0 top
D10  YEU25CA0505AC  [DFN10_2D5X1P05H06]  90.17 191.64 180 bottom
D11  YEU25CA0505AC  [DFN10_2D5X1P05H06]  63.07 49.86 180 bottom
D12  PDWL5R0R35-DFN1006  [DFN1006-2L]  23.62 193.29 90 top
D13  PDWL5R0R35-DFN1006  [DFN1006-2L]  23.62 194.69 90 top
D14  SMB30J58CA  [SMB_TVS]  4.83 12.19 0 top
D15  SMB30J58CA  [SMB_TVS]  4.83 12.19 0 bottom
D16  YEU25CA0505AC  [DFN10_2D5X1P05H06]  23.88 25.78 0 bottom
D17  SMB30J58CA  [SMB_TVS]  4.83 7.75 0 top
D18  SMB30J58CA  [SMB_TVS]  4.83 7.75 0 bottom
D19  YEU25CA0505AC  [DFN10_2D5X1P05H06]  27.25 25.73 0 bottom
D20  SMB30J58CA  [SMB_TVS]  29.84 9.7 90 top
D21  YEU25CA0505AC  [DFN10_2D5X1P05H06]  41.15 22.86 0 bottom
D22  SMB30J58CA  [SMB_TVS]  29.88 9.6 90 bottom
D23  YEU25CA0505AC  [DFN10_2D5X1P05H06]  44.45 22.86 0 bottom
D24  YEU25CA0505AC  [DFN10_2D5X1P05H06]  59.44 22.86 0 bottom
D25  SMB30J58CA  [SMB_TVS]  50.04 9.7 90 top
D26  SMB30J58CA  [SMB_TVS]  50.04 9.6 90 bottom
D27  YEU25CA0505AC  [DFN10_2D5X1P05H06]  62.74 22.86 0 bottom
D28  SMB30J58CA  [SMB_TVS]  70.23 9.7 90 top
D29  YEU25CA0505AC  [DFN10_2D5X1P05H06]  77.72 22.86 0 bottom
D30  SMB30J58CA  [SMB_TVS]  70.23 9.6 90 bottom
D31  YEU25CA0505AC  [DFN10_2D5X1P05H06]  81.03 22.86 0 bottom
D32  YEU25CA0505AC  [DFN10_2D5X1P05H06]  96.01 22.86 0 bottom
D33  SMB30J58CA  [SMB_TVS]  90.42 9.7 90 top
D34  SMB30J58CA  [SMB_TVS]  90.42 9.6 90 bottom
D35  YEU25CA0505AC  [DFN10_2D5X1P05H06]  99.31 22.86 0 bottom
D36  SMB30J58CA  [SMB_TVS]  110.62 9.7 90 top
D37  YEU25CA0505AC  [DFN10_2D5X1P05H06]  114.3 22.86 0 bottom
D38  SMB30J58CA  [SMB_TVS]  110.62 9.6 90 bottom
D39  YEU25CA0505AC  [DFN10_2D5X1P05H06]  117.6 22.86 0 bottom
D40  SMB30J58CA  [SMB_TVS]  130.81 9.7 90 top
D41  SMB30J58CA  [SMB_TVS]  130.81 9.6 90 bottom
D42  YEU25CA0505AC  [DFN10_2D5X1P05H06]  132.59 23.24 0 bottom
D43  YEU25CA0505AC  [DFN10_2D5X1P05H06]  135.89 23.24 0 bottom
D44  YEU25CA0505AC  [DFN10_2D5X1P05H06]  138.07 48.64 90 bottom
D45  YEU25CA0505AC  [DFN10_2D5X1P05H06]  137.97 51.94 90 bottom
D46  S100  [SMA]  4.7 52.7 0 bottom
D47  S100  [SMA]  12.19 52.7 0 bottom
D48  S100  [SMA]  4.7 65.91 0 bottom
D49  S100  [SMA]  12.19 65.91 0 bottom
D50  S100  [SMA]  19.68 52.7 0 bottom
D51  S100  [SMA]  27.05 52.7 0 bottom
D52  S100  [SMA]  19.68 65.91 0 bottom
D53  S100  [SMA]  27.18 65.91 0 bottom
D54  S7239-300Y  [SOD323]  109.3 50.88 180 top
D55  YEU25CA0505AC  [DFN10_2D5X1P05H06]  99.19 49.78 0 bottom
D56  YEU25CA0505AC  [DFN10_2D5X1P05H06]  102.62 49.78 0 bottom
D57  YEU25CA0505AC  [DFN10_2D5X1P05H06]  105.92 49.78 180 bottom
D58  1N4148WS  [SOD323]  2.16 176.02 270 bottom
D59  SMBJ58A  [SMB]  3.17 182.63 270 bottom
D60  SMBJ58A  [SMB]  24.92 165.99 0 bottom
D61  SMBJ58A  [SMB]  20.7 182.88 270 top
D62  SMBJ26A  [SMB]  20.22 190.5 90 top
D63  SMBJ58A  [SMB]  10.24 156.29 180 bottom
D64  CZRQC52C3V9A-HF  [SM0402_D]  147.09 99.82 90 bottom
D65  BAT54H  [SOD323]  87.53 110.11 90 top
D66  YEU25CA0505AC  [DFN10_2D5X1P05H06]  66.62 49.86 0 bottom
DB1  PH127-5X2-S  [CONHS5X2P127_WP]  118.11 63.25 270 bottom
DC_IN1  ATX-6P-P4.2  [ATX6P-WP]  11.89 173.31 0 bottom
F1  1206SMD200  [SM1206_F]  4.52 54.69 180 top
F2  1206SMD200  [SM1206_F]  12.01 54.69 180 top
F3  1206SMD200  [SM1206_F]  4.52 67.89 180 top
F4  1206SMD200  [SM1206_F]  12.01 67.89 180 top
F5  1206SMD200  [SM1206_F]  19.51 54.69 180 top
F6  1206SMD200  [SM1206_F]  26.87 54.69 180 top
F7  1206SMD200  [SM1206_F]  19.51 67.89 180 top
F8  1206SMD200  [SM1206_F]  27 67.89 180 top
F9  0805SMD100  [SM0805_F]  104.47 50.24 270 top
FB1  30/3A-L3  [SM0603_B]  145.06 79.25 180 bottom
FB2  60/3A-L3  [SM0603_B]  141.73 78.74 270 top
FB3  60/3A-L3  [SM0603_B]  81.69 81.99 0 top
FB5  120-L2  [SM0402_B]  136.14 134.11 270 top
FB7  @30/3A-L3  [SM0603_B]  139.95 177.93 0 top
FB8  600/2A-L5  [SM0805_B]  11.38 13.41 90 top
FB9  600/2A-L5  [SM0805_B]  14.05 13.41 90 top
FB10  600/2A-L5  [SM0805_B]  19 13.41 90 top
FB11  600/2A-L5  [SM0805_B]  23.19 13.41 90 top
FB12  600/2A-L5  [SM0805_B]  33.53 13.46 90 top
FB13  600/2A-L5  [SM0805_B]  37.72 13.46 90 top
FB16  600/2A-L5  [SM0805_B]  53.72 13.46 90 top
FB17  600/2A-L5  [SM0805_B]  57.91 13.46 90 top
FB18  600/2A-L5  [SM0805_B]  73.91 13.46 90 top
FB19  600/2A-L5  [SM0805_B]  78.11 13.46 90 top
FB20  600/2A-L5  [SM0805_B]  94.11 13.46 90 top
FB21  600/2A-L5  [SM0805_B]  98.3 13.46 90 top
FB22  600/2A-L5  [SM0805_B]  114.3 13.46 90 top
FB23  600/2A-L5  [SM0805_B]  118.49 13.46 90 top
FB26  600/2A-L5  [SM0805_B]  134.49 13.46 90 top
FB27  600/2A-L5  [SM0805_B]  138.68 13.46 90 top
FB28  PBY160808T-331Y-N  [SM0603_B]  101.75 92.33 0 top
FB29  PBY160808T-331Y-N  [SM0603_B]  101.75 90.42 0 bottom
FB30  PBY160808T-331Y-N  [SM0603_B]  98.83 80.9 270 bottom
FB31  PBY160808T-331Y-N  [SM0603_B]  104.17 83.57 90 top
FB32  PBY160808T-331Y-N  [SM0603_B]  102.11 89.79 0 top
FB33  PBY160808T-331Y-N  [SM0603_B]  95.53 80.14 0 bottom
FB34  PBY160808T-331Y-N  [SM0603_B]  101.75 88.77 0 bottom
FB35  30/3A-L3  [SM0603_B]  45.67 98.88 0 top
FB36  30/3A-L3  [SM0603_B]  44.65 59.51 180 top
FB37  30/3A-L3  [SM0603_B]  45.67 89.23 0 top
FB38  30/3A-L3  [SM0603_B]  10.67 180.85 180 top
FB39  120-L2  [SM0402_B]  151.5 98.9 270 top
FB40  120-L3  [SM0603_B]  150.11 153.42 180 bottom
FB41  120-L3  [SM0603_B]  150.11 155.32 0 bottom
FB46  30/3A-L3  [SM0603_B]  75.64 149.56 180 top
FB47  @600/2A-L5  [SM0805_B]  2.59 16.38 270 top
FB48  @600/2A-L5  [SM0805_B]  2.59 16.38 270 bottom
FB49  @600/2A-L5  [SM0805_B]  148.74 62.23 270 bottom
FB50  @600/2A-L5  [SM0805_B]  148.74 62.23 270 top
FL1  @GCMF1210PA-900T1  [CM-CHOKE-1210-4P]  157.48 177.42 180 bottom
FL2  ACT45B/51UH  [CM-CHOKE-ACT45B-4P]  33.91 191.9 0 bottom
H1  @HOLE  [HOLETB354C158D158N-V8_OSP]  11.25 188 0 top
H2  @HOLE  [HOLETB354C158D158N-V8_OSP]  148.75 165.1 0 top
H3  @HOLE  [HOLETB354C158D158N-V8_OSP]  11.25 28.1 0 top
H4  @HOLE  [HOLETB354C158D158N-V8_OSP]  148.75 28.1 0 top
HDMI1  HDMI-19P-A-VERTICAL-S  [HDMI-S19PV_CHD-8X0A-190]  102.36 44.45 0 bottom
J1  203456-0003  [BTBS-BGA699-MIRMEZ-203456003]  80 125.56 0 top
J4  @PH127-5X2-S  [CONHS5X2P127_WP]  121.92 123.95 270 bottom
J7  @PH254-3X1  [CONHD3X1]  32.38 72.9 180 bottom
J11  PH254-4X1  [CONHD4X1]  33.91 80.77 180 bottom
J13  PH254-4X1  [CONHD4X1]  33.91 76.83 180 bottom
J14  BTB050-60X2-H3.25-S  [BTBS-60X2P05-QSH-01]  106.25 168.26 0 top
JPPCIE1  PH254-2X1  [CONHD2X1]  33.78 84.71 180 bottom
JPSON1  PH254-2X1  [CONHD2X1]  157.61 36.83 270 bottom
JSIM1  SIM-6-S  [SIM_N0601B010]  122.56 183.46 0 bottom
JSIM2  SIM-6-S  [SIM_N0601B010]  137.1 183.46 0 bottom
L1  GTHW2012PC-900T1  [CM-CHOKE-2012-4P]  109.3 52.76 0 top
L2  GTHW2012PC-900T1  [CM-CHOKE-2012-4P]  109.3 54.66 0 top
L3  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  81.03 54.81 270 top
L4  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  102.18 67.69 0 top
L5  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  83.31 54.81 270 top
L6  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  102.18 65.41 0 top
L7  GTHW2012PC-900T1  [CM-CHOKE-2012-4P]  64.01 52.45 270 bottom
L8  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  97.92 52.7 270 bottom
L9  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  99.95 52.7 270 bottom
L10  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  101.85 52.7 270 bottom
L11  GCMF2012PA-900T  [CM-CHOKE-2012-4P]  103.76 52.7 270 bottom
L12  SIC2717/10UH  [SER2918H_LS-178]  20.84 145.2 0 top
LANACT1  LED0603-G  [SM0603_LED]  32 40.79 0 bottom
LANACT2  LED0603-G  [SM0603_LED]  44.58 38.35 0 bottom
LANACT3  LED0603-G  [SM0603_LED]  62.87 38.35 0 bottom
LANACT4  LED0603-G  [SM0603_LED]  81.15 38.35 0 bottom
LANACT5  LED0603-G  [SM0603_LED]  99.44 38.35 0 bottom
LANACT6  LED0603-G  [SM0603_LED]  117.73 38.35 0 bottom
LANACT7  LED0603-G  [SM0603_LED]  136.02 38.73 0 bottom
LANACT8  LED0603-G  [SM0603_LED]  125.48 58.93 90 bottom
LANLINK1  LED0805-G+Y  [SM0805_LED-4]  32 38.61 180 bottom
LANLINK2  LED0805-G+Y  [SM0805_LED-4]  47.62 37.47 270 bottom
LANLINK3  LED0805-G+Y  [SM0805_LED-4]  65.91 37.47 270 bottom
LANLINK4  LED0805-G+Y  [SM0805_LED-4]  84.2 37.47 270 bottom
LANLINK5  LED0805-G+Y  [SM0805_LED-4]  102.97 37.21 270 bottom
LANLINK6  LED0805-G+Y  [SM0805_LED-4]  120.78 37.47 270 bottom
LANLINK7  LED0805-G+Y  [SM0805_LED-4]  139.06 37.85 270 bottom
LANLINK8  LED0805-G+Y  [SM0805_LED-4]  127.76 59.05 270 bottom
LED1  LED0603-G  [SM0603_LED]  128.27 129.92 180 bottom
LED2  LED0603-G  [SM0603_LED]  128.27 131.83 180 bottom
MCUCON1  PH254-3X1  [CONHD3X1]  157.61 165.23 270 bottom
MHB1  STANDOFF-M3X1.5-T1.4  [HOLEC256D177-PT]  100.89 184.91 180 bottom
MHB2  STANDOFF-M3X1.5-T1.4  [HOLEC256D177-PT]  110.82 184.91 180 bottom
MHE1  STANDOFF-M3X2.45  [HOLEC256D166-PT]  141.49 156.9 180 bottom
MHM1  STANDOFF-M3X6.6  [HOLEC256D166-PT]  146.81 36.05 0 top
NCSI1  WF100-10/BM10B-SRSS-TB  [WF100S-10P-BM10B-SRSS]  154.8 76.7 270 bottom
NGFF1  NGFF-75P,H8.5-B  [M2-67H85-B-3052]  150.42 184.92 90 bottom
NMEA0183  WF200-8/B08B-PASK(LF)(SN)  [WF200D-8P-PASK]  54.55 197.56 180 bottom
NMEA2000  WF200-8/B08B-PASK(LF)(SN)  [WF200D-8P-PASK]  29.55 197.56 180 bottom
NOREF  -  []  103.49 26.92 0 top
NOREF#2  -  []  102.24 31.62 90 top
NOREF#3  -  []  102.74 60.96 270 top
NOREF#4  -  []  126.44 156.29 0 top
NOREF#5  -  []  81.27 34.52 0 top
NOREF#6  -  []  79.73 108.89 270 top
NOREF#7  -  []  71.11 33.48 0 top
NOREF#8  -  []  142.57 70.92 0 top
NOREF#9  -  []  69.19 84.48 0 top
NOREF#10  -  []  148.26 99.44 0 top
NOREF#11  -  []  109.72 27.3 0 top
NOREF#12  -  []  101.68 35.1 270 top
NOREF#13  -  []  107.94 31.62 0 top
NOREF#14  -  []  117.81 18.72 0 top
NOREF#15  -  []  146.25 95.33 90 top
NOREF#16  -  []  69.16 83.36 270 top
NOREF#17  -  []  137.11 90.37 90 top
NOREF#18  -  []  146.57 109.66 270 top
NOREF#19  -  []  61.14 53.09 270 top
NOREF#20  -  []  125.86 31.89 0 top
NOREF#21  -  []  67.94 89.61 90 top
NOREF#22  -  []  68.33 12.4 0 top
NOREF#23  -  []  64.58 102.12 270 top
NOREF#24  -  []  110.16 158.32 90 top
NOREF#25  -  []  103.25 59.94 90 top
NOREF#26  -  []  117.93 173.56 0 top
NOREF#27  -  []  34.06 192.79 0 top
NOREF#28  -  []  142.42 120.27 90 top
NOREF#29  -  []  144.98 187.02 90 top
NOREF#30  -  []  68.83 57.4 270 top
NOREF#31  -  []  123.77 47.5 0 top
NOREF#32  -  []  151.64 136.17 90 top
NOREF#33  -  []  58.99 101.51 0 top
NOREF#34  -  []  7.65 77.22 0 top
NOREF#35  -  []  134.82 56.85 0 top
NOREF#36  -  []  68.1 109.6 270 top
NOREF#37  -  []  135.41 102.23 0 top
NOREF#38  -  []  54.18 37.39 0 top
NOREF#39  -  []  37 177.8 0 top
NOREF#40  -  []  76.33 52.58 270 top
NOREF#41  -  []  128.6 54.72 90 top
NOREF#42  -  []  25.07 179.07 0 top
NOREF#43  -  []  41.14 122.81 90 top
NOREF#44  -  []  141.22 149.52 90 top
NOREF#45  -  []  103.58 139.88 0 top
NOREF#46  -  []  57.28 166.27 90 top
NOREF#47  -  []  63.32 17.09 90 top
NOREF#48  -  []  58.88 73.19 270 top
NOREF#49  -  []  123.9 17.09 90 top
NOREF#50  -  []  136.73 75.62 0 top
NOREF#51  -  []  129.36 64.76 90 top
NOREF#52  -  []  35.94 17.44 90 top
NOREF#53  -  []  28.63 27.46 90 top
NOREF#54  -  []  62.94 177.34 0 top
NOREF#55  -  []  134.35 37.01 0 top
NOREF#56  -  []  41.71 112.57 270 top
NOREF#57  -  []  136.89 27.23 0 top
NOREF#58  -  []  127.69 56.52 0 top
NOREF#59  -  []  36.27 39.07 90 top
NOREF#60  -  []  62.1 59.33 90 top
NOREF#61  -  []  134.06 149.3 90 top
NOREF#62  -  []  119.63 153.9 270 top
NOREF#63  -  []  56.29 95.22 270 top
NOREF#64  -  []  53.04 28.69 0 top
NOREF#65  -  []  70.33 79.96 0 top
NOREF#66  -  []  62.32 178.53 90 top
NOREF#67  -  []  61.46 113.06 90 top
NOREF#68  -  []  98.04 34.43 270 top
NOREF#69  -  []  150.88 177.55 90 top
NOREF#70  -  []  116.48 39.24 90 top
NOREF#71  -  []  39.45 65.61 0 top
NOREF#72  -  []  127.47 130.32 0 top
NOREF#73  -  []  54.76 147.32 0 top
NOREF#74  -  []  138.42 176.56 0 top
NOREF#75  -  []  137.46 29.73 270 top
NOREF#76  -  []  117.3 35.51 90 top
NOREF#77  -  []  70.94 27.7 0 top
NOREF#78  -  []  56.63 23.8 270 top
NOREF#79  -  []  126.99 40.89 0 top
NOREF#80  -  []  156.87 191.9 0 top
NOREF#81  -  []  115.44 17.4 90 top
NOREF#82  -  []  58.29 109.6 270 top
NOREF#83  -  []  127.97 26.78 0 top
NOREF#84  -  []  132.36 85.6 90 top
NOREF#85  -  []  58.99 91.68 0 top
NOREF#86  -  []  83.64 28.52 0 top
NOREF#87  -  []  21.39 116.33 0 top
NOREF#88  -  []  140.26 128.07 270 top
NOREF#89  -  []  74.42 23.76 270 top
NOREF#90  -  []  48.92 56.26 270 top
NOREF#91  -  []  147.68 120.78 90 top
NOREF#92  -  []  102.79 30.4 270 top
NOREF#93  -  []  1.27 179.83 90 top
NOREF#94  -  []  120.88 44.15 0 top
NOREF#95  -  []  40.31 112.57 270 top
NOREF#96  -  []  89.28 109.73 90 top
NOREF#97  -  []  18.15 39.55 0 top
NOREF#98  -  []  66.84 94.45 270 top
NOREF#99  -  []  34.91 33.65 90 top
NOREF#100  -  []  62.05 109.87 0 top
NOREF#101  -  []  102.79 32.37 90 top
NOREF#102  -  []  73.1 78.92 270 top
NOREF#103  -  []  148.56 130.81 270 top
NOREF#104  -  []  152.8 101.34 270 top
NOREF#105  -  []  138.51 26.72 0 top
NOREF#106  -  []  102.18 29.86 270 top
NOREF#107  -  []  103.12 63.75 270 top
NOREF#108  -  []  136.73 76.02 90 top
NOREF#109  -  []  57.34 113.03 270 top
NOREF#110  -  []  151.13 20.4 90 top
NOREF#111  -  []  143.23 100.51 0 top
NOREF#112  -  []  47.96 141.15 270 top
NOREF#113  -  []  47.09 188.26 0 top
NOREF#114  -  []  70.33 141.43 0 top
NOREF#115  -  []  28.65 31.99 0 top
NOREF#116  -  []  108.28 152.86 0 top
NOREF#117  -  []  56.02 113.37 270 top
NOREF#118  -  []  83.06 57.1 90 top
NOREF#119  -  []  107.9 27.7 0 top
NOREF#120  -  []  141.6 17.4 90 top
NOREF#121  -  []  153.09 92.76 270 top
NOREF#122  -  []  67.64 175.59 90 top
NOREF#123  -  []  93.98 23.76 270 top
NOREF#124  -  []  73.1 76.5 270 top
NOREF#125  -  []  50.9 53.54 0 top
NOREF#126  -  []  124.41 42.41 0 top
NOREF#127  -  []  61.8 82.63 0 top
NOREF#128  -  []  109.72 30.61 0 top
NOREF#129  -  []  133.38 133.6 0 top
NOREF#130  -  []  52.7 36.59 270 top
NOREF#131  -  []  43.32 34.47 270 top
NOREF#132  -  []  19.89 25.97 90 top
NOREF#133  -  []  53.07 32.26 0 top
NOREF#134  -  []  79.65 41 270 top
NOREF#135  -  []  134.37 148.21 90 top
NOREF#136  -  []  100.89 29.35 270 top
NOREF#137  -  []  43.13 63.07 0 top
NOREF#138  -  []  48.81 150.75 0 top
NOREF#139  -  []  58.24 170.89 90 top
NOREF#140  -  []  89.61 28.33 270 top
NOREF#141  -  []  53.2 33.65 90 top
NOREF#142  -  []  48.63 26.92 0 top
NOREF#143  -  []  60.02 91.64 270 top
NOREF#144  -  []  136.13 34.9 0 top
NOREF#145  -  []  22.35 38.56 90 top
NOREF#146  -  []  144.73 134.54 0 top
NOREF#147  -  []  15.67 39.87 90 top
NOREF#148  -  []  130.42 24.18 0 top
NOREF#149  -  []  23.28 28.54 0 top
NOREF#150  -  []  68.53 110.06 270 top
NOREF#151  -  []  120.47 33.92 0 top
NOREF#152  -  []  95 35.89 90 top
NOREF#153  -  []  55.93 82.93 90 top
NOREF#154  -  []  68.83 25.78 90 top
NOREF#155  -  []  56.26 73.46 0 top
NOREF#156  -  []  119.96 35.1 0 top
NOREF#157  -  []  120.56 26.04 0 top
NOREF#158  -  []  130.35 160.1 90 top
NOREF#159  -  []  149.2 69.16 0 top
NOREF#160  -  []  56.72 94.77 270 top
NOREF#161  -  []  73.1 31.51 270 top
NOREF#162  -  []  49.4 58.2 270 top
NOREF#163  -  []  51.77 143.56 270 top
NOREF#164  -  []  103.28 93.97 90 top
NOREF#165  -  []  50.11 73.14 90 top
NOREF#166  -  []  38.48 23.76 270 top
NOREF#167  -  []  139.55 106.93 0 top
NOREF#168  -  []  108.28 155.27 0 top
NOREF#169  -  []  78.3 25.65 0 top
NOREF#170  -  []  149.42 12.67 90 top
NOREF#171  -  []  17.65 35.34 0 top
NOREF#172  -  []  83.64 26.34 0 top
NOREF#173  -  []  42.88 112.06 270 top
NOREF#174  -  []  65.63 156.54 0 top
NOREF#175  -  []  60.78 60.4 0 top
NOREF#176  -  []  133.35 53.07 90 top
NOREF#177  -  []  153.47 151.46 90 top
NOREF#178  -  []  127.53 66.57 0 top
NOREF#179  -  []  29.46 191.01 0 top
NOREF#180  -  []  0 0 0 top
NOREF#181  -  []  74.55 36.84 270 top
NOREF#182  -  []  51.59 109.51 270 top
NOREF#183  -  []  116.47 34.47 270 top
NOREF#184  -  []  7.19 77.65 0 top
NOREF#185  -  []  124.41 42.68 270 top
NOREF#186  -  []  140.07 27.94 0 top
NOREF#187  -  []  91.39 31.51 0 top
NOREF#188  -  []  151.92 21.72 270 top
NOREF#189  -  []  102.13 34.67 0 top
NOREF#190  -  []  70.18 108.89 0 top
NOREF#191  -  []  31.2 41.19 270 top
NOREF#192  -  []  54.81 26.4 0 top
NOREF#193  -  []  88.85 105.36 0 top
NOREF#194  -  []  131.95 156.97 90 top
NOREF#195  -  []  60.83 82.93 90 top
NOREF#196  -  []  132.07 42.24 0 top
NOREF#197  -  []  128.51 24.18 0 top
NOREF#198  -  []  36.53 31.23 90 top
NOREF#199  -  []  48.87 0.16 0 top
NOREF#200  -  []  53.07 30.48 0 top
NOREF#201  -  []  20.78 20.82 90 top
NOREF#202  -  []  14.1 81.18 90 top
NOREF#203  -  []  126.19 26.81 270 top
NOREF#204  -  []  139.55 106.93 0 top
NOREF#205  -  []  149.22 127.23 270 top
NOREF#206  -  []  77.72 18.38 270 top
NOREF#207  -  []  129.41 66.57 90 top
NOREF#208  -  []  62.61 70.74 270 top
NOREF#209  -  []  40.44 104.22 90 top
NOREF#210  -  []  118.19 152.6 0 top
NOREF#211  -  []  57.04 113.37 270 top
NOREF#212  -  []  150.5 121.75 270 top
NOREF#213  -  []  18.02 29.21 0 top
NOREF#214  -  []  131.69 53.52 0 top
NOREF#215  -  []  73.65 23.8 0 top
NOREF#216  -  []  91.43 29.21 0 top
NOREF#217  -  []  100.32 27.61 0 top
NOREF#218  -  []  120.22 26.34 0 top
NOREF#219  -  []  38.98 23.8 0 top
NOREF#220  -  []  75.01 100.28 0 top
NOREF#221  -  []  146.25 95.33 0 top
NOREF#222  -  []  40.01 95.99 270 top
NOREF#223  -  []  52.7 31.51 0 top
NOREF#224  -  []  20.37 29.32 90 top
NOREF#225  -  []  86.39 52.7 0 top
NOREF#226  -  []  19.13 20.78 90 top
NOREF#227  -  []  84.51 28.97 270 top
NOREF#228  -  []  118.52 42.85 0 top
NOREF#229  -  []  105.16 52.51 90 top
NOREF#230  -  []  134.4 150.11 0 top
NOREF#231  -  []  108.06 36.63 0 top
NOREF#232  -  []  149.17 72.09 270 top
NOREF#233  -  []  73.1 27.17 0 top
NOREF#234  -  []  134.37 151 90 top
NOREF#235  -  []  83.95 31.62 90 top
NOREF#236  -  []  75.46 99.31 0 top
NOREF#237  -  []  111.26 36.27 90 top
NOREF#238  -  []  117.93 174.17 270 top
NOREF#239  -  []  75.46 101.85 0 top
NOREF#240  -  []  138.89 173.15 270 top
NOREF#241  -  []  60.35 67.44 0 top
NOREF#242  -  []  124.09 46.94 90 top
NOREF#243  -  []  118.12 34.52 270 top
NOREF#244  -  []  62.23 113.03 270 top
NOREF#245  -  []  65.23 188.16 0 top
NOREF#246  -  []  132.51 126.44 90 top
NOREF#247  -  []  137.21 121.31 0 top
NOREF#248  -  []  124.41 152.86 0 top
NOREF#249  -  []  60.66 109.74 0 top
NOREF#250  -  []  123.53 64.92 90 top
NOREF#251  -  []  69.84 33.48 0 top
NOREF#252  -  []  134.47 76.63 0 top
NOREF#253  -  []  150.57 178.64 0 top
NOREF#254  -  []  108.58 155.83 0 top
NOREF#255  -  []  139.34 174.12 0 top
NOREF#256  -  []  96.14 197.59 0 top
NOREF#257  -  []  120.51 33.78 0 top
NOREF#258  -  []  55.37 109.56 270 top
NOREF#259  -  []  93.21 23.8 270 top
NOREF#260  -  []  83.03 100.63 0 top
NOREF#261  -  []  89.4 33.48 0 top
NOREF#262  -  []  117.3 35.51 0 top
NOREF#263  -  []  60.78 64.59 0 top
NOREF#264  -  []  52.57 36.63 270 top
NOREF#265  -  []  98.69 36.02 90 top
NOREF#266  -  []  46.02 27.75 270 top
NOREF#267  -  []  75.01 103.84 0 top
NOREF#268  -  []  134.06 145.75 90 top
NOREF#269  -  []  5.56 117.22 90 top
NOREF#270  -  []  42.71 93.12 0 top
NOREF#271  -  []  2.03 9.65 0 top
NOREF#272  -  []  137.54 184.15 270 top
NOREF#273  -  []  37.83 96.22 0 top
NOREF#274  -  []  143.75 92.91 90 top
NOREF#275  -  []  89.67 33.48 90 top
NOREF#276  -  []  11.2 126.39 0 top
NOREF#277  -  []  34.67 18.41 90 top
NOREF#278  -  []  25.55 54.69 0 top
NOREF#279  -  []  149.05 151.46 0 top
NOREF#280  -  []  37.71 23.8 0 top
NOREF#281  -  []  52.32 54.51 90 top
NOREF#282  -  []  43.81 125.32 270 top
NOREF#283  -  []  66.23 91.68 0 top
NOREF#284  -  []  89.61 29.71 0 top
NOREF#285  -  []  63.12 109.56 270 top
NOREF#286  -  []  63.68 24.54 90 top
NOREF#287  -  []  53.04 26.15 0 top
NOREF#288  -  []  61.21 109.43 90 top
NOREF#289  -  []  57.91 75.69 270 top
NOREF#290  -  []  132.54 26.07 90 top
NOREF#291  -  []  116.18 42.85 0 top
NOREF#292  -  []  51.94 52.58 270 top
NOREF#293  -  []  100.32 29.21 0 top
NOREF#294  -  []  127.2 76.63 270 top
NOREF#295  -  []  74.5 18.72 270 top
NOREF#296  -  []  126.57 51.3 90 top
NOREF#297  -  []  7.44 158.19 0 top
NOREF#298  -  []  16.64 36.44 90 top
NOREF#299  -  []  146.86 131.11 270 top
NOREF#300  -  []  51.55 33.48 0 top
NOREF#301  -  []  10.82 80.21 90 top
NOREF#302  -  []  138.89 174.83 90 top
NOREF#303  -  []  79.73 109.3 0 top
NOREF#304  -  []  55.24 55.88 270 top
NOREF#305  -  []  34.75 32.4 270 top
NOREF#306  -  []  66.19 51.33 0 top
NOREF#307  -  []  73.71 29.35 270 top
NOREF#308  -  []  138.05 183.13 90 top
NOREF#309  -  []  49.53 26.29 0 top
NOREF#310  -  []  39.45 66.75 0 top
NOREF#311  -  []  79.49 36.63 270 top
NOREF#312  -  []  56.87 58.6 270 top
NOREF#313  -  []  83.9 51.42 90 top
NOREF#314  -  []  70.47 34.09 0 top
NOREF#315  -  []  13.53 117.17 90 top
NOREF#316  -  []  128.91 143.5 270 top
NOREF#317  -  []  139.12 106.1 270 top
NOREF#318  -  []  21.11 67.09 90 top
NOREF#319  -  []  45.42 63.2 0 top
NOREF#320  -  []  53.07 28.19 0 top
NOREF#321  -  []  139.78 43.26 270 top
NOREF#322  -  []  120.47 29.58 0 top
NOREF#323  -  []  18.19 194.44 0 top
NOREF#324  -  []  46.05 70.18 270 top
NOREF#325  -  []  91.69 38.76 90 top
NOREF#326  -  []  51.94 72.17 90 top
NOREF#327  -  []  116.23 70.46 270 top
NOREF#328  -  []  28.75 30.56 0 top
NOREF#329  -  []  89.53 33.52 90 top
NOREF#330  -  []  149.87 189.45 0 top
NOREF#331  -  []  134.4 148.46 0 top
NOREF#332  -  []  92.57 23.8 270 top
NOREF#333  -  []  138.25 83.64 90 top
NOREF#334  -  []  38.34 23.8 270 top
NOREF#335  -  []  14.76 22.1 0 top
NOREF#336  -  []  128.15 141.72 270 top
NOREF#337  -  []  9.68 107.21 90 top
NOREF#338  -  []  45.72 35.97 90 top
NOREF#339  -  []  138.48 89.03 0 top
NOREF#340  -  []  135.52 34.85 270 top
NOREF#341  -  []  138.22 121.31 90 top
NOREF#342  -  []  61.21 109.44 270 top
NOREF#343  -  []  102.57 64.06 0 top
NOREF#344  -  []  138.91 79.55 0 top
NOREF#345  -  []  98.64 38.75 270 top
NOREF#346  -  []  137.67 120.73 90 top
NOREF#347  -  []  135.97 68.78 90 top
NOREF#348  -  []  74.52 108.15 90 top
NOREF#349  -  []  17.98 31.61 90 top
NOREF#350  -  []  57.33 91.39 0 top
NOREF#351  -  []  146.41 88.95 0 top
NOREF#352  -  []  128.87 0.16 0 top
NOREF#353  -  []  65.61 79.53 0 top
NOREF#354  -  []  40.39 93.22 270 top
NOREF#355  -  []  53.04 29.98 270 top
NOREF#356  -  []  65.66 31.62 270 top
NOREF#357  -  []  42.7 79.91 90 top
NOREF#358  -  []  83.9 28.97 0 top
NOREF#359  -  []  127.33 54.72 90 top
NOREF#360  -  []  137.69 103.38 0 top
NOREF#361  -  []  133.48 120.68 90 top
NOREF#362  -  []  62.69 68.63 0 top
NOREF#363  -  []  103.14 93.93 90 top
NOREF#364  -  []  54.48 75.68 90 top
NOREF#365  -  []  122.94 181.74 270 top
NOREF#366  -  []  151.64 121.75 270 top
NOREF#367  -  []  107.9 32.12 0 top
NOREF#368  -  []  102.18 32.65 0 top
NOREF#369  -  []  20.37 30.09 90 top
NOREF#370  -  []  102.79 30.3 90 top
NOREF#371  -  []  131.27 36.61 90 top
NOREF#372  -  []  137.69 105.66 0 top
NOREF#373  -  []  36.96 192.18 90 top
NOREF#374  -  []  52.53 145.52 90 top
NOREF#375  -  []  40.44 96.44 270 top
NOREF#376  -  []  63.74 27.61 0 top
NOREF#377  -  []  136.6 17.09 90 top
NOREF#378  -  []  124.08 46.94 0 top
NOREF#379  -  []  66.92 27.56 0 top
NOREF#380  -  []  123.25 65.53 0 top
NOREF#381  -  []  124.45 41.91 0 top
NOREF#382  -  []  99.56 34.52 0 top
NOREF#383  -  []  30.56 35.45 0 top
NOREF#384  -  []  102.87 104.24 270 top
NOREF#385  -  []  108.28 159.18 0 top
NOREF#386  -  []  120.62 68.4 90 top
NOREF#387  -  []  56.29 95.22 0 top
NOREF#388  -  []  91.92 102.51 0 top
NOREF#389  -  []  58.42 37.52 270 top
NOREF#390  -  []  65.56 34.67 0 top
NOREF#391  -  []  44.97 34.52 270 top
NOREF#392  -  []  132.98 42.24 90 top
NOREF#393  -  []  102.23 25.78 0 top
NOREF#394  -  []  151.87 17.02 270 top
NOREF#395  -  []  114.11 25.65 90 top
NOREF#396  -  []  115.39 124 0 top
NOREF#397  -  []  80.72 35.51 90 top
NOREF#398  -  []  51.84 76.07 0 top
NOREF#399  -  []  138.32 79.24 90 top
NOREF#400  -  []  12.57 80.67 90 top
NOREF#401  -  []  138.76 34.3 0 top
NOREF#402  -  []  24.59 53.54 0 top
NOREF#403  -  []  57.56 82.63 0 top
NOREF#404  -  []  34.75 31.48 0 top
NOREF#405  -  []  73.91 36.84 270 top
NOREF#406  -  []  31.17 36.44 90 top
NOREF#407  -  []  50.06 51.71 0 top
NOREF#408  -  []  121.11 170.13 0 top
NOREF#409  -  []  149.66 70.1 0 top
NOREF#410  -  []  74.12 84.56 270 top
NOREF#411  -  []  89.61 28.69 0 top
NOREF#412  -  []  45.42 61.93 0 top
NOREF#413  -  []  82.6 26.99 270 top
NOREF#414  -  []  56.34 76 270 top
NOREF#415  -  []  36.2 17.4 90 top
NOREF#416  -  []  74.05 36.88 270 top
NOREF#417  -  []  146.56 173.2 270 top
NOREF#418  -  []  50.44 52.7 270 top
NOREF#419  -  []  37.59 17.4 90 top
NOREF#420  -  []  37.49 105.03 0 top
NOREF#421  -  []  42.42 34.43 270 top
NOREF#422  -  []  130.1 136.22 90 top
NOREF#423  -  []  125.48 181.73 90 top
NOREF#424  -  []  39.99 25.63 90 top
NOREF#425  -  []  137.24 46.47 90 top
NOREF#426  -  []  98.84 64.9 0 top
NOREF#427  -  []  93.5 99.51 90 top
NOREF#428  -  []  146.86 106.1 270 top
NOREF#429  -  []  57.48 71.83 90 top
NOREF#430  -  []  139.24 140.18 90 top
NOREF#431  -  []  110.3 52.16 90 top
NOREF#432  -  []  145.75 173.69 270 top
NOREF#433  -  []  34.46 32.28 0 top
NOREF#434  -  []  39.12 23.76 270 top
NOREF#435  -  []  2.99 171.04 0 top
NOREF#436  -  []  125.3 38.34 90 top
NOREF#437  -  []  133.6 44.59 270 top
NOREF#438  -  []  131.57 177.89 270 top
NOREF#439  -  []  88.09 93.65 270 top
NOREF#440  -  []  49.78 104.27 0 top
NOREF#441  -  []  20.47 20.47 90 top
NOREF#442  -  []  134.37 144.65 0 top
NOREF#443  -  []  146.56 95.67 90 top
NOREF#444  -  []  85.2 27.56 0 top
NOREF#445  -  []  61.04 169.98 0 top
NOREF#446  -  []  54.1 55.85 270 top
NOREF#447  -  []  112.73 37.2 90 top
NOREF#448  -  []  49.1 56.92 0 top
NOREF#449  -  []  129.17 55.42 0 top
NOREF#450  -  []  14.17 108 0 top
NOREF#451  -  []  16.5 36.4 0 top
NOREF#452  -  []  17.93 107.7 0 top
NOREF#453  -  []  123.19 41.63 90 top
NOREF#454  -  []  34.11 18.72 0 top
NOREF#455  -  []  23.42 28.57 90 top
NOREF#456  -  []  98.74 101.85 0 top
NOREF#457  -  []  124.97 71.86 270 top
NOREF#458  -  []  89.31 106.68 90 top
NOREF#459  -  []  101.35 52.51 90 top
NOREF#460  -  []  128 29.59 0 top
NOREF#461  -  []  60.78 102.08 270 top
NOREF#462  -  []  131.05 42.24 0 top
NOREF#463  -  []  32.46 28.65 0 top
NOREF#464  -  []  41.14 100.28 0 top
NOREF#465  -  []  56.39 82.63 0 top
NOREF#466  -  []  120.51 28.19 0 top
NOREF#467  -  []  11.25 109.3 90 top
NOREF#468  -  []  41.14 90.63 0 top
NOREF#469  -  []  14.94 190.7 0 top
NOREF#470  -  []  127.97 30.85 90 top
NOREF#471  -  []  58.99 102.12 270 top
NOREF#472  -  []  47.73 56.79 0 top
NOREF#473  -  []  71.49 33.65 90 top
NOREF#474  -  []  65.7 26.04 0 top
NOREF#475  -  []  147.8 99.01 0 top
NOREF#476  -  []  135.08 53.31 0 top
NOREF#477  -  []  137.67 121.73 90 top
NOREF#478  -  []  129.25 42.52 0 top
NOREF#479  -  []  133.65 165.3 90 top
NOREF#480  -  []  57.81 37.52 0 top
NOREF#481  -  []  55.45 104.5 270 top
NOREF#482  -  []  143.87 94.44 0 top
NOREF#483  -  []  103.71 18.72 0 top
NOREF#484  -  []  126.19 26.53 0 top
NOREF#485  -  []  58.62 82.93 90 top
NOREF#486  -  []  55.11 113.06 90 top
NOREF#487  -  []  60.48 68.45 0 top
NOREF#488  -  []  52.65 56.97 0 top
NOREF#489  -  []  94.86 25.65 90 top
NOREF#490  -  []  56.69 83.91 270 top
NOREF#491  -  []  65.79 176.78 0 top
NOREF#492  -  []  30.61 28.7 0 top
NOREF#493  -  []  98.84 91.64 0 top
NOREF#494  -  []  125.02 51.04 90 top
NOREF#495  -  []  47.27 34.67 0 top
NOREF#496  -  []  120.51 28.83 0 top
NOREF#497  -  []  153.09 135.84 90 top
NOREF#498  -  []  19.05 109.26 90 top
NOREF#499  -  []  60.82 68.15 0 top
NOREF#500  -  []  45.42 29.07 0 top
NOREF#501  -  []  80.19 108.46 0 top
NOREF#502  -  []  73.56 78.49 0 top
NOREF#503  -  []  53.1 33.48 90 top
NOREF#504  -  []  138.84 107.24 90 top
NOREF#505  -  []  88.72 37.58 90 top
NOREF#506  -  []  54.86 168.66 90 top
NOREF#507  -  []  126.19 31 270 top
NOREF#508  -  []  10.61 72 0 top
NOREF#509  -  []  135.42 47.49 90 top
NOREF#510  -  []  18.57 20.47 90 top
NOREF#511  -  []  119.39 180.47 90 top
NOREF#512  -  []  18.02 31.11 0 top
NOREF#513  -  []  63.78 173.99 0 top
NOREF#514  -  []  138.76 33.03 0 top
NOREF#515  -  []  122.81 77.83 270 top
NOREF#516  -  []  19.25 81.57 270 top
NOREF#517  -  []  134.51 44.63 270 top
NOREF#518  -  []  21.16 25.97 90 top
NOREF#519  -  []  124.76 182.04 270 top
NOREF#520  -  []  0 0 0 top
NOREF#521  -  []  155.23 114.35 90 top
NOREF#522  -  []  56.79 37.52 0 top
NOREF#523  -  []  75.46 102.74 0 top
NOREF#524  -  []  62.12 36.63 270 top
NOREF#525  -  []  73.1 76.78 0 top
NOREF#526  -  []  135.84 56.34 90 top
NOREF#527  -  []  31.66 190.3 0 top
NOREF#528  -  []  40.39 17.44 90 top
NOREF#529  -  []  131.06 161.52 270 top
NOREF#530  -  []  126.44 154.61 270 top
NOREF#531  -  []  152.68 15.57 0 top
NOREF#532  -  []  140.59 53.85 0 top
NOREF#533  -  []  94.69 109.91 270 top
NOREF#534  -  []  18.19 54.69 0 top
NOREF#535  -  []  45.49 70.48 0 top
NOREF#536  -  []  104.06 26.78 90 top
NOREF#537  -  []  105.71 26.34 270 top
NOREF#538  -  []  142.6 74.22 270 top
NOREF#539  -  []  56.64 52.81 270 top
NOREF#540  -  []  39.45 64.21 0 top
NOREF#541  -  []  134.37 149.36 90 top
NOREF#542  -  []  107.96 33.48 90 top
NOREF#543  -  []  114.87 25.65 0 top
NOREF#544  -  []  55.5 75.69 270 top
NOREF#545  -  []  138.81 26.16 0 top
NOREF#546  -  []  63.82 102.12 270 top
NOREF#547  -  []  131.34 55.38 270 top
NOREF#548  -  []  65.66 31.62 90 top
NOREF#549  -  []  83.61 99.16 0 top
NOREF#550  -  []  25.11 178.82 0 top
NOREF#551  -  []  151.52 101.85 270 top
NOREF#552  -  []  121.41 17.4 90 top
NOREF#553  -  []  70.98 30.48 0 top
NOREF#554  -  []  50.11 72.14 90 top
NOREF#555  -  []  134.35 37.01 270 top
NOREF#556  -  []  130.56 36.27 90 top
NOREF#557  -  []  70.48 108.33 0 top
NOREF#558  -  []  63.28 177.04 0 top
NOREF#559  -  []  140.94 62.66 0 top
NOREF#560  -  []  61.98 36.59 270 top
NOREF#561  -  []  115.04 85.67 90 top
NOREF#562  -  []  93.71 106.95 270 top
NOREF#563  -  []  25.08 37.44 0 top
NOREF#564  -  []  54.85 26.54 0 top
NOREF#565  -  []  141.55 122.15 0 top
NOREF#566  -  []  140.34 103.85 270 top
NOREF#567  -  []  140.63 46.1 0 top
NOREF#568  -  []  152.78 121.77 270 top
NOREF#569  -  []  99.24 105.79 0 top
NOREF#570  -  []  12.39 21.79 90 top
NOREF#571  -  []  148.34 193.84 90 top
NOREF#572  -  []  142.6 72.09 0 top
NOREF#573  -  []  103.45 27.42 0 top
NOREF#574  -  []  119.94 134.92 270 top
NOREF#575  -  []  151.21 135.71 0 top
NOREF#576  -  []  135.08 18.72 0 top
NOREF#577  -  []  72.11 81.23 90 top
NOREF#578  -  []  63.58 35.51 90 top
NOREF#579  -  []  19.75 26.54 0 top
NOREF#580  -  []  50.9 100.03 0 top
NOREF#581  -  []  44.87 2.26 90 top
NOREF#582  -  []  149.2 71.2 0 top
NOREF#583  -  []  43.69 17.4 90 top
NOREF#584  -  []  34.75 27.7 0 top
NOREF#585  -  []  58.99 113.06 90 top
NOREF#586  -  []  134.37 144.66 90 top
NOREF#587  -  []  145.16 120.68 90 top
NOREF#588  -  []  58.3 109.59 90 top
NOREF#589  -  []  107.65 156.64 270 top
NOREF#590  -  []  128.73 139.75 270 top
NOREF#591  -  []  140.09 176.41 0 top
NOREF#592  -  []  137.47 133.88 90 top
NOREF#593  -  []  53.04 26.43 270 top
NOREF#594  -  []  141.01 26.42 0 top
NOREF#595  -  []  115.04 86.54 0 top
NOREF#596  -  []  121.34 44.58 0 top
NOREF#597  -  []  37.36 105.44 90 top
NOREF#598  -  []  17.98 31.61 0 top
NOREF#599  -  []  61.8 181.53 90 top
NOREF#600  -  []  53.04 27.7 0 top
NOREF#601  -  []  47.09 186.64 90 top
NOREF#602  -  []  18.41 81.6 90 top
NOREF#603  -  []  135.41 105.66 0 top
NOREF#604  -  []  68.35 150.75 0 top
NOREF#605  -  []  83.82 18.38 270 top
NOREF#606  -  []  137.24 45.83 0 top
NOREF#607  -  []  10.69 108.99 0 top
NOREF#608  -  []  74.5 18.72 0 top
NOREF#609  -  []  101.73 139.42 270 top
NOREF#610  -  []  72.21 144.32 270 top
NOREF#611  -  []  144.57 107.79 0 top
NOREF#612  -  []  102.18 31.93 0 top
NOREF#613  -  []  89.61 28.05 0 top
NOREF#614  -  []  115.52 117.58 0 top
NOREF#615  -  []  130.54 44.03 0 top
NOREF#616  -  []  119.28 109.47 0 top
NOREF#617  -  []  118.36 17.4 90 top
NOREF#618  -  []  142.8 175.56 270 top
NOREF#619  -  []  17.27 36.44 90 top
NOREF#620  -  []  140.27 100.08 0 top
NOREF#621  -  []  19.38 130.53 90 top
NOREF#622  -  []  134.76 50.15 0 top
NOREF#623  -  []  131.9 158.29 270 top
NOREF#624  -  []  146.43 134.09 270 top
NOREF#625  -  []  72.47 37.39 0 top
NOREF#626  -  []  128.57 27.83 270 top
NOREF#627  -  []  31.83 29.98 0 top
NOREF#628  -  []  101.3 105.23 0 top
NOREF#629  -  []  57.23 17.09 90 top
NOREF#630  -  []  137.54 127.61 270 top
NOREF#631  -  []  97.28 34.43 270 top
NOREF#632  -  []  134.11 177.19 90 top
NOREF#633  -  []  126.49 36.97 270 top
NOREF#634  -  []  50.44 55.37 0 top
NOREF#635  -  []  118.61 29.21 0 top
NOREF#636  -  []  110.54 140.13 270 top
NOREF#637  -  []  37.82 95.07 0 top
NOREF#638  -  []  144.09 17.09 90 top
NOREF#639  -  []  102.18 33.92 0 top
NOREF#640  -  []  46.02 29.35 270 top
NOREF#641  -  []  116.64 73.86 90 top
NOREF#642  -  []  89.61 32.4 270 top
NOREF#643  -  []  136.22 79.55 0 top
NOREF#644  -  []  132.92 134.04 270 top
NOREF#645  -  []  140.59 53.34 90 top
NOREF#646  -  []  47.38 25.78 90 top
NOREF#647  -  []  123.44 153.29 90 top
NOREF#648  -  []  142.82 102.95 0 top
NOREF#649  -  []  73.1 77.65 270 top
NOREF#650  -  []  142.6 74.22 0 top
NOREF#651  -  []  126.9 157.86 0 top
NOREF#652  -  []  47.37 32.18 90 top
NOREF#653  -  []  86.37 0.56 90 top
NOREF#654  -  []  31.86 29.84 0 top
NOREF#655  -  []  149.2 75.87 0 top
NOREF#656  -  []  29.16 191.57 0 top
NOREF#657  -  []  127.03 177.52 0 top
NOREF#658  -  []  60.73 71.88 0 top
NOREF#659  -  []  100.89 27.75 270 top
NOREF#660  -  []  63.32 174.42 270 top
NOREF#661  -  []  43.43 63.63 0 top
NOREF#662  -  []  152.04 151.89 0 top
NOREF#663  -  []  122.35 26.78 90 top
NOREF#664  -  []  13.46 106.58 90 top
NOREF#665  -  []  31.62 36.8 270 top
NOREF#666  -  []  56.02 113.37 0 top
NOREF#667  -  []  66.57 102.51 90 top
NOREF#668  -  []  65.05 51.33 90 top
NOREF#669  -  []  31.62 36.8 0 top
NOREF#670  -  []  66.88 100.91 0 top
NOREF#671  -  []  72.29 84.1 270 top
NOREF#672  -  []  82.6 29.35 270 top
NOREF#673  -  []  98.27 100.28 0 top
NOREF#674  -  []  114.3 -29.84 0 top
NOREF#675  -  []  114.91 109.52 0 top
NOREF#676  -  []  97.78 36.63 270 top
NOREF#677  -  []  73.14 27.3 0 top
NOREF#678  -  []  39.57 94.56 0 top
NOREF#679  -  []  69.88 80.39 0 top
NOREF#680  -  []  45.72 60.58 90 top
NOREF#681  -  []  138.89 173.69 0 top
NOREF#682  -  []  58.12 83.95 270 top
NOREF#683  -  []  66.22 30.4 270 top
NOREF#684  -  []  35.64 17.09 90 top
NOREF#685  -  []  141 89.41 90 top
NOREF#686  -  []  127.27 88.01 90 top
NOREF#687  -  []  93.84 23.8 0 top
NOREF#688  -  []  95.38 91.43 90 top
NOREF#689  -  []  145.44 103.38 0 top
NOREF#690  -  []  39.88 108.74 90 top
NOREF#691  -  []  50.9 54.94 0 top
NOREF#692  -  []  134.82 48.37 0 top
NOREF#693  -  []  131.48 55.42 270 top
NOREF#694  -  []  102.5 93.93 0 top
NOREF#695  -  []  143.05 72.52 0 top
NOREF#696  -  []  123.19 181.7 270 top
NOREF#697  -  []  121.74 27.7 270 top
NOREF#698  -  []  102.23 30.61 90 top
NOREF#699  -  []  85.06 101.55 90 top
NOREF#700  -  []  65.58 64.77 0 top
NOREF#701  -  []  48.46 75.62 270 top
NOREF#702  -  []  107.9 28.05 0 top
NOREF#703  -  []  131.97 52.91 90 top
NOREF#704  -  []  138.89 175.69 0 top
NOREF#705  -  []  55.7 173.56 0 top
NOREF#706  -  []  116.33 34.43 270 top
NOREF#707  -  []  19.01 70.75 90 top
NOREF#708  -  []  102.36 29.95 270 top
NOREF#709  -  []  46.3 72.21 0 top
NOREF#710  -  []  62.1 64.14 270 top
NOREF#711  -  []  157.38 112.27 0 top
NOREF#712  -  []  143.64 70.6 90 top
NOREF#713  -  []  57.07 53.26 270 top
NOREF#714  -  []  49.81 107.95 0 top
NOREF#715  -  []  76.57 25.65 0 top
NOREF#716  -  []  48.13 12.4 0 top
NOREF#717  -  []  147.17 121.79 270 top
NOREF#718  -  []  73.1 30.75 0 top
NOREF#719  -  []  60.83 18.41 90 top
NOREF#720  -  []  66.8 176.05 90 top
NOREF#721  -  []  74.96 108.61 90 top
NOREF#722  -  []  138.51 26.11 90 top
NOREF#723  -  []  73.18 56.9 270 top
NOREF#724  -  []  119.08 135.2 0 top
NOREF#725  -  []  19.76 29.32 0 top
NOREF#726  -  []  62.61 51.84 90 top
NOREF#727  -  []  65.66 25.78 0 top
NOREF#728  -  []  135.25 135.76 90 top
NOREF#729  -  []  133.73 54.98 90 top
NOREF#730  -  []  127.56 42.3 270 top
NOREF#731  -  []  76.89 104.32 270 top
NOREF#732  -  []  67.44 83.78 270 top
NOREF#733  -  []  10.13 107.65 0 top
NOREF#734  -  []  101.31 65.81 0 top
NOREF#735  -  []  52.15 37.58 90 top
NOREF#736  -  []  34.75 28.05 0 top
NOREF#737  -  []  54.94 76 0 top
NOREF#738  -  []  153.09 91.62 270 top
NOREF#739  -  []  84.51 31.93 270 top
NOREF#740  -  []  56.52 55.84 270 top
NOREF#741  -  []  132.92 87.96 90 top
NOREF#742  -  []  45.97 138.18 90 top
NOREF#743  -  []  134.89 42.24 90 top
NOREF#744  -  []  55.7 77.85 270 top
NOREF#745  -  []  71.39 33.48 90 top
NOREF#746  -  []  3.2 67.89 0 top
NOREF#747  -  []  128.91 141.57 270 top
NOREF#748  -  []  64.99 91.68 270 top
NOREF#749  -  []  49.35 77.9 270 top
NOREF#750  -  []  39.52 37.52 0 top
NOREF#751  -  []  121.06 71.48 90 top
NOREF#752  -  []  129.69 69.88 90 top
NOREF#753  -  []  39.45 63.93 270 top
NOREF#754  -  []  38.51 37.52 0 top
NOREF#755  -  []  150.24 121.79 270 top
NOREF#756  -  []  114.3 153.7 90 top
NOREF#757  -  []  146.86 104.95 270 top
NOREF#758  -  []  126.19 30.09 0 top
NOREF#759  -  []  137.07 75.31 0 top
NOREF#760  -  []  68.99 108.94 270 top
NOREF#761  -  []  128.46 55.3 0 top
NOREF#762  -  []  15.39 82.04 0 top
NOREF#763  -  []  136.41 34.9 270 top
NOREF#764  -  []  35.36 27.42 90 top
NOREF#765  -  []  119.28 108.97 90 top
NOREF#766  -  []  30.59 31.11 0 top
NOREF#767  -  []  39.58 37.2 90 top
NOREF#768  -  []  34.49 37.99 270 top
NOREF#769  -  []  135.23 87.96 0 top
NOREF#770  -  []  139.34 175.26 0 top
NOREF#771  -  []  75.01 106.25 0 top
NOREF#772  -  []  129.39 42.48 270 top
NOREF#773  -  []  138.55 18.41 90 top
NOREF#774  -  []  62.45 91.68 270 top
NOREF#775  -  []  126.31 143.94 0 top
NOREF#776  -  []  19.12 21.79 90 top
NOREF#777  -  []  33.4 33.52 90 top
NOREF#778  -  []  27.46 126.87 0 top
NOREF#779  -  []  18.95 80.29 0 top
NOREF#780  -  []  103.49 27.56 0 top
NOREF#781  -  []  126.9 156.72 0 top
NOREF#782  -  []  143.64 70.61 270 top
NOREF#783  -  []  88.13 33.48 0 top
NOREF#784  -  []  145.11 184.23 90 top
NOREF#785  -  []  83.39 34.24 90 top
NOREF#786  -  []  126.23 28.57 0 top
NOREF#787  -  []  129.07 129.52 90 top
NOREF#788  -  []  55.49 36.27 0 top
NOREF#789  -  []  127 139.06 0 top
NOREF#790  -  []  150.57 179.78 0 top
NOREF#791  -  []  138.71 35.05 0 top
NOREF#792  -  []  147.57 134.09 270 top
NOREF#793  -  []  34.42 32.42 0 top
NOREF#794  -  []  128.61 42.52 270 top
NOREF#795  -  []  126.14 71.86 270 top
NOREF#796  -  []  145.31 181.86 0 top
NOREF#797  -  []  77.42 18.72 270 top
NOREF#798  -  []  59.23 73.33 270 top
NOREF#799  -  []  122.94 181.73 90 top
NOREF#800  -  []  39.57 104.22 0 top
NOREF#801  -  []  17.65 35.06 90 top
NOREF#802  -  []  130.63 140.67 0 top
NOREF#803  -  []  49.35 53.52 270 top
NOREF#804  -  []  97.52 51.83 90 top
NOREF#805  -  []  76.07 53.98 270 top
NOREF#806  -  []  144.4 127.46 270 top
NOREF#807  -  []  20.38 25.93 90 top
NOREF#808  -  []  21.84 77.32 270 top
NOREF#809  -  []  47.32 75.62 270 top
NOREF#810  -  []  64.57 67.77 90 top
NOREF#811  -  []  101.42 64.06 0 top
NOREF#812  -  []  133.78 163.78 90 top
NOREF#813  -  []  43.43 63.12 90 top
NOREF#814  -  []  55.83 18.72 0 top
NOREF#815  -  []  86.44 51.38 90 top
NOREF#816  -  []  46.61 46.51 90 top
NOREF#817  -  []  61.8 84.25 270 top
NOREF#818  -  []  66.55 84.07 90 top
NOREF#819  -  []  130.7 42.24 90 top
NOREF#820  -  []  71.2 108.51 270 top
NOREF#821  -  []  136.22 182.83 0 top
NOREF#822  -  []  157.42 112.01 0 top
NOREF#823  -  []  55.07 56.97 0 top
NOREF#824  -  []  144.09 18.72 0 top
NOREF#825  -  []  83.26 102.11 0 top
NOREF#826  -  []  80.35 37.95 90 top
NOREF#827  -  []  142.19 134.92 270 top
NOREF#828  -  []  135.17 40.06 90 top
NOREF#829  -  []  76.89 101.14 270 top
NOREF#830  -  []  136.86 27.85 0 top
NOREF#831  -  []  21.03 20.78 90 top
NOREF#832  -  []  19.81 130.07 90 top
NOREF#833  -  []  48.03 73.53 0 top
NOREF#834  -  []  36.4 128.32 0 top
NOREF#835  -  []  111.25 138.71 90 top
NOREF#836  -  []  22.68 20.82 90 top
NOREF#837  -  []  135.13 36.44 90 top
NOREF#838  -  []  149.2 73.86 0 top
NOREF#839  -  []  61.21 113.03 270 top
NOREF#840  -  []  97.61 18.72 0 top
NOREF#841  -  []  43.47 63.37 0 top
NOREF#842  -  []  58.42 25.67 90 top
NOREF#843  -  []  38.51 102.87 0 top
NOREF#844  -  []  106.55 33.52 90 top
NOREF#845  -  []  148.79 125.81 0 top
NOREF#846  -  []  58.28 25.63 90 top
NOREF#847  -  []  120.4 181.48 90 top
NOREF#848  -  []  47.65 187.95 90 top
NOREF#849  -  []  100.28 27.47 0 top
NOREF#850  -  []  116.96 18.41 90 top
NOREF#851  -  []  0 0 0 top
NOREF#852  -  []  138.8 30.1 0 top
NOREF#853  -  []  65.56 68.2 0 top
NOREF#854  -  []  98.5 66.22 0 top
NOREF#855  -  []  144.87 2.26 90 top
NOREF#856  -  []  136.89 29.59 0 top
NOREF#857  -  []  30.61 36.07 270 top
NOREF#858  -  []  75.01 105.46 0 top
NOREF#859  -  []  56.32 113.03 270 top
NOREF#860  -  []  65.61 32.65 0 top
NOREF#861  -  []  104.01 138.46 90 top
NOREF#862  -  []  128.57 29.73 270 top
NOREF#863  -  []  128.02 163.55 270 top
NOREF#864  -  []  56.13 23.76 270 top
NOREF#865  -  []  132.69 88.09 0 top
NOREF#866  -  []  47.45 143.56 0 top
NOREF#867  -  []  81.99 26.71 0 top
NOREF#868  -  []  128.91 12.5 270 top
NOREF#869  -  []  45.42 63.8 270 top
NOREF#870  -  []  49.71 58.55 270 top
NOREF#871  -  []  140.15 176.67 0 top
NOREF#872  -  []  48.92 76.48 0 top
NOREF#873  -  []  54.48 51.82 90 top
NOREF#874  -  []  39.88 112.12 270 top
