# Allegro board POE TPS23881.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#3482  -  []  55.24 52.79 270 top
NOREF#3483  -  []  150.22 115.14 0 top
NOREF#3484  -  []  53.39 56.31 270 top
NOREF#3485  -  []  152.04 150.75 0 top
NOREF#3486  -  []  131.9 164.64 0 top
NOREF#3487  -  []  134.95 135.71 0 top
NOREF#3488  -  []  53.75 49.35 270 top
NOREF#3489  -  []  89.32 32.28 0 top
NOREF#3490  -  []  52.19 73.14 90 top
NOREF#3491  -  []  107.94 27.56 0 top
NOREF#3492  -  []  15.39 80.16 90 top
NOREF#3493  -  []  146.28 121.75 270 top
NOREF#3494  -  []  136.53 64.52 0 top
NOREF#3495  -  []  145.31 180.72 0 top
NOREF#3496  -  []  98.41 36.02 0 top
NOREF#3497  -  []  20.93 117.17 0 top
NOREF#3498  -  []  66.22 28.05 90 top
NOREF#3499  -  []  70.31 38.37 0 top
NOREF#3500  -  []  17.69 34.57 0 top
NOREF#3501  -  []  140.28 44.27 0 top
NOREF#3502  -  []  46.87 5.46 270 top
NOREF#3503  -  []  141.38 107.24 90 top
NOREF#3504  -  []  124.66 76.4 90 top
NOREF#3505  -  []  37.2 36.27 0 top
NOREF#3506  -  []  41 99.92 0 top
NOREF#3507  -  []  107.21 156.18 270 top
NOREF#3508  -  []  76.89 103.17 270 top
NOREF#3509  -  []  145.87 179.25 0 top
NOREF#3510  -  []  63.12 177.01 270 top
NOREF#3511  -  []  21.41 77.77 270 top
NOREF#3512  -  []  84.51 32.65 270 top
NOREF#3513  -  []  154.82 12.87 0 top
NOREF#3514  -  []  54.94 51.51 0 top
NOREF#3515  -  []  150.91 177.8 0 top
NOREF#3516  -  []  47.32 28.97 0 top
NOREF#3517  -  []  137.24 44.56 90 top
NOREF#3518  -  []  54.61 17.44 90 top
NOREF#3519  -  []  36.96 177.55 0 top
NOREF#3520  -  []  121.78 27.56 0 top
NOREF#3521  -  []  120.53 25.78 90 top
NOREF#3522  -  []  42.75 25.67 90 top
NOREF#3523  -  []  43.8 34.47 0 top
NOREF#3524  -  []  111.66 158.75 0 top
NOREF#3525  -  []  98.6 95.61 90 top
NOREF#3526  -  []  5.87 85.6 0 top
NOREF#3527  -  []  93.42 36.2 90 top
NOREF#3528  -  []  56.26 56.97 0 top
NOREF#3529  -  []  118.54 26.42 0 top
NOREF#3530  -  []  150.88 178.69 90 top
NOREF#3531  -  []  43.05 36.59 270 top
NOREF#3532  -  []  14.94 30.8 0 top
NOREF#3533  -  []  118.28 173.86 0 top
NOREF#3534  -  []  123.95 76.86 90 top
NOREF#3535  -  []  124.74 65.66 0 top
NOREF#3536  -  []  88.98 109.68 0 top
NOREF#3537  -  []  92.84 36.31 90 top
NOREF#3538  -  []  127.58 164.01 0 top
NOREF#3539  -  []  58.85 109.91 270 top
NOREF#3540  -  []  29.06 27.91 90 top
NOREF#3541  -  []  137.17 34.9 270 top
NOREF#3542  -  []  56.77 23.76 270 top
NOREF#3543  -  []  150.93 151.46 90 top
NOREF#3544  -  []  66.37 91.11 90 top
NOREF#3545  -  []  134.06 144.6 90 top
NOREF#3546  -  []  107.9 29.98 270 top
NOREF#3547  -  []  125.02 44.56 90 top
NOREF#3548  -  []  61.04 25.67 90 top
NOREF#3549  -  []  90.1 107.37 90 top
NOREF#3550  -  []  48.63 27.56 0 top
NOREF#3551  -  []  2.67 41.27 270 top
NOREF#3552  -  []  132.89 120.22 90 top
NOREF#3553  -  []  140.64 184.45 270 top
NOREF#3554  -  []  51.64 71.83 90 top
NOREF#3555  -  []  109.72 31.37 0 top
NOREF#3556  -  []  128.19 35.89 90 top
NOREF#3557  -  []  18.69 106.58 90 top
NOREF#3558  -  []  148.64 193.5 90 top
NOREF#3559  -  []  131.02 37.58 90 top
NOREF#3560  -  []  107.94 30.48 0 top
NOREF#3561  -  []  134.37 146.94 90 top
NOREF#3562  -  []  37.59 18.41 90 top
NOREF#3563  -  []  52.53 54.43 0 top
NOREF#3564  -  []  156.81 113.65 90 top
NOREF#3565  -  []  10.41 53.89 0 top
NOREF#3566  -  []  86.44 52.39 90 top
NOREF#3567  -  []  46.39 145.41 0 top
NOREF#3568  -  []  51.59 56.92 0 top
NOREF#3569  -  []  58.48 95.85 270 top
NOREF#3570  -  []  115.39 122.12 90 top
NOREF#3571  -  []  114.88 17.09 90 top
NOREF#3572  -  []  50.06 143.13 0 top
NOREF#3573  -  []  157.81 74.05 90 top
NOREF#3574  -  []  91.64 100.95 90 top
NOREF#3575  -  []  65.1 35.1 270 top
NOREF#3576  -  []  90.83 99.42 0 top
NOREF#3577  -  []  122.38 78.28 0 top
NOREF#3578  -  []  133.34 42.24 90 top
NOREF#3579  -  []  54.69 104.5 270 top
NOREF#3580  -  []  89.61 28.97 270 top
NOREF#3581  -  []  60.96 109.4 270 top
NOREF#3582  -  []  40.08 18.72 0 top
NOREF#3583  -  []  76.89 103.56 270 top
NOREF#3584  -  []  30.56 36.08 0 top
NOREF#3585  -  []  141.73 102.87 90 top
NOREF#3586  -  []  23.37 38.56 90 top
NOREF#3587  -  []  43 66.34 270 top
NOREF#3588  -  []  75.06 23.76 270 top
NOREF#3589  -  []  108.51 27.42 90 top
NOREF#3590  -  []  125.43 182.04 0 top
NOREF#3591  -  []  83.9 29.58 0 top
NOREF#3592  -  []  55.99 23.8 0 top
NOREF#3593  -  []  104.26 18.41 90 top
NOREF#3594  -  []  43.46 65.91 0 top
NOREF#3595  -  []  67.36 157.94 90 top
NOREF#3596  -  []  118.24 173.61 90 top
NOREF#3597  -  []  55.12 167.13 270 top
NOREF#3598  -  []  123.77 46.48 0 top
NOREF#3599  -  []  54.43 146.48 0 top
NOREF#3600  -  []  126.19 29.07 0 top
NOREF#3601  -  []  37.97 177.55 90 top
NOREF#3602  -  []  64.87 2.26 90 top
NOREF#3603  -  []  134.95 103.81 0 top
NOREF#3604  -  []  81.43 53.94 90 top
NOREF#3605  -  []  89.28 36.59 270 top
NOREF#3606  -  []  122.38 25.73 0 top
NOREF#3607  -  []  52.1 103.96 0 top
NOREF#3608  -  []  134.06 145.21 0 top
NOREF#3609  -  []  88.52 12.5 0 top
NOREF#3610  -  []  43.13 79.45 90 top
NOREF#3611  -  []  99.71 101.6 90 top
NOREF#3612  -  []  72.72 53.54 270 top
NOREF#3613  -  []  140.87 150.6 0 top
NOREF#3614  -  []  21.02 26.54 0 top
NOREF#3615  -  []  128.27 165.86 270 top
NOREF#3616  -  []  49.23 25.73 0 top
NOREF#3617  -  []  138.33 78.23 90 top
NOREF#3618  -  []  82.45 53.98 0 top
NOREF#3619  -  []  17.98 29.07 0 top
NOREF#3620  -  []  132.84 42.28 90 top
NOREF#3621  -  []  66.84 94.45 0 top
NOREF#3622  -  []  33.81 41.02 0 top
NOREF#3623  -  []  28.63 29.34 0 top
NOREF#3624  -  []  6.63 108.36 90 top
NOREF#3625  -  []  70.99 36.59 270 top
NOREF#3626  -  []  96.29 108.48 90 top
NOREF#3627  -  []  148.08 127.23 270 top
NOREF#3628  -  []  126.35 37.01 270 top
NOREF#3629  -  []  145.62 142.72 0 top
NOREF#3630  -  []  51.23 104.95 270 top
NOREF#3631  -  []  152.44 30.8 0 top
NOREF#3632  -  []  20.93 115.9 0 top
NOREF#3633  -  []  61.61 33.86 90 top
NOREF#3634  -  []  135.25 175.03 90 top
NOREF#3635  -  []  93.98 35.89 90 top
NOREF#3636  -  []  46.02 26.99 270 top
NOREF#3637  -  []  55.83 171.75 0 top
NOREF#3638  -  []  34.28 36.63 0 top
NOREF#3639  -  []  134.37 145.8 90 top
NOREF#3640  -  []  43 64.34 0 top
NOREF#3641  -  []  139.23 139.83 0 top
NOREF#3642  -  []  41.72 25.63 90 top
NOREF#3643  -  []  45.8 70.14 270 top
NOREF#3644  -  []  102.79 33.01 90 top
NOREF#3645  -  []  144.98 188.16 90 top
NOREF#3646  -  []  38.11 36.27 90 top
NOREF#3647  -  []  67.97 55.52 0 top
NOREF#3648  -  []  61.04 168.1 90 top
NOREF#3649  -  []  128.41 141.66 270 top
NOREF#3650  -  []  146.09 147.96 0 top
NOREF#3651  -  []  54.23 75.65 270 top
NOREF#3652  -  []  82.4 24.99 90 top
NOREF#3653  -  []  144.2 70.92 270 top
NOREF#3654  -  []  54.85 27.3 0 top
NOREF#3655  -  []  30.65 28.96 0 top
NOREF#3656  -  []  128.09 64.76 90 top
NOREF#3657  -  []  31.79 12.4 270 top
NOREF#3658  -  []  56.4 36.88 270 top
NOREF#3659  -  []  94.97 98.88 90 top
NOREF#3660  -  []  63.32 173.56 0 top
NOREF#3661  -  []  56.82 57.28 90 top
NOREF#3662  -  []  146.33 140.36 90 top
NOREF#3663  -  []  91.39 26.4 0 top
NOREF#3664  -  []  116.2 36.59 270 top
NOREF#3665  -  []  120.47 32.65 0 top
NOREF#3666  -  []  144.98 104.09 0 top
NOREF#3667  -  []  62.94 189.03 270 top
NOREF#3668  -  []  145.7 100.2 90 top
NOREF#3669  -  []  67.64 175.59 0 top
NOREF#3670  -  []  156.54 182.83 90 top
NOREF#3671  -  []  13.84 117.12 90 top
NOREF#3672  -  []  132.46 157.99 270 top
NOREF#3673  -  []  60.82 59.64 0 top
NOREF#3674  -  []  103.45 27.06 0 top
NOREF#3675  -  []  80.52 33.9 90 top
NOREF#3676  -  []  52.55 194.36 90 top
NOREF#3677  -  []  55.31 104.53 270 top
NOREF#3678  -  []  133.72 34.92 0 top
NOREF#3679  -  []  126.23 32.64 0 top
NOREF#3680  -  []  14.38 107.21 0 top
NOREF#3681  -  []  58.04 57.28 90 top
NOREF#3682  -  []  107.07 140 270 top
NOREF#3683  -  []  150.8 122.1 270 top
NOREF#3684  -  []  39.45 110.69 0 top
NOREF#3685  -  []  125.3 38.62 0 top
NOREF#3686  -  []  47.07 26.34 0 top
NOREF#3687  -  []  146.13 171.78 0 top
NOREF#3688  -  []  45.16 45.42 90 top
NOREF#3689  -  []  31.17 31.61 90 top
NOREF#3690  -  []  113.87 153.24 0 top
NOREF#3691  -  []  12.4 20.78 90 top
NOREF#3692  -  []  149.5 151.89 0 top
NOREF#3693  -  []  38.76 86.49 90 top
NOREF#3694  -  []  121.08 32.37 90 top
NOREF#3695  -  []  106.41 33.48 0 top
NOREF#3696  -  []  131.43 26.04 0 top
NOREF#3697  -  []  60.82 62.81 0 top
NOREF#3698  -  []  46.38 146.56 0 top
NOREF#3699  -  []  101.28 97.38 0 top
NOREF#3700  -  []  127.01 139.07 90 top
NOREF#3701  -  []  52.1 145.06 90 top
NOREF#3702  -  []  138.22 120.17 90 top
NOREF#3703  -  []  131.78 92.28 90 top
NOREF#3704  -  []  84.51 30.4 270 top
NOREF#3705  -  []  124.74 66.8 0 top
NOREF#3706  -  []  55.42 29.35 270 top
NOREF#3707  -  []  107.05 33.48 90 top
NOREF#3708  -  []  80.19 109.73 0 top
NOREF#3709  -  []  129.08 75.49 270 top
NOREF#3710  -  []  37.83 36.27 0 top
NOREF#3711  -  []  49.83 140 270 top
NOREF#3712  -  []  54.94 76 270 top
NOREF#3713  -  []  54.56 113.37 0 top
NOREF#3714  -  []  148.51 127.69 270 top
NOREF#3715  -  []  62.66 109.87 270 top
NOREF#3716  -  []  85.04 103.68 270 top
NOREF#3717  -  []  127.83 55.3 0 top
NOREF#3718  -  []  28.05 199.26 0 top
NOREF#3719  -  []  30.59 35.94 0 top
NOREF#3720  -  []  93.64 110.03 270 top
NOREF#3721  -  []  137.04 75.06 90 top
NOREF#3722  -  []  47.32 29.86 270 top
NOREF#3723  -  []  131.78 66.3 0 top
NOREF#3724  -  []  126.61 51.44 0 top
NOREF#3725  -  []  111.96 36.23 90 top
NOREF#3726  -  []  133.3 156.01 0 top
NOREF#3727  -  []  136.88 89.97 270 top
NOREF#3728  -  []  126.54 130.61 270 top
NOREF#3729  -  []  80.26 36.59 270 top
NOREF#3730  -  []  36.53 27.17 0 top
NOREF#3731  -  []  83.95 25.78 90 top
NOREF#3732  -  []  120.52 25.78 0 top
NOREF#3733  -  []  137.39 88.82 0 top
NOREF#3734  -  []  18.41 80.59 90 top
NOREF#3735  -  []  142.09 98.63 0 top
NOREF#3736  -  []  88.39 92.63 270 top
NOREF#3737  -  []  124.41 50.41 90 top
NOREF#3738  -  []  56.77 54.86 90 top
NOREF#3739  -  []  47.93 28.05 90 top
NOREF#3740  -  []  57.87 37.2 90 top
NOREF#3741  -  []  58.05 93.66 0 top
NOREF#3742  -  []  130.96 37.9 0 top
NOREF#3743  -  []  151.41 15.57 0 top
NOREF#3744  -  []  128 26.92 0 top
NOREF#3745  -  []  143.28 103.38 0 top
NOREF#3746  -  []  127.97 31.61 90 top
NOREF#3747  -  []  136.53 64.52 90 top
NOREF#3748  -  []  134.44 159.05 270 top
NOREF#3749  -  []  126.19 30.72 0 top
NOREF#3750  -  []  85.8 25.73 0 top
NOREF#3751  -  []  71.49 36.63 0 top
NOREF#3752  -  []  115.71 34.47 270 top
NOREF#3753  -  []  11.89 123.39 90 top
NOREF#3754  -  []  36.53 31.51 0 top
NOREF#3755  -  []  62.06 38.75 270 top
NOREF#3756  -  []  146 134.54 0 top
NOREF#3757  -  []  39.45 110.16 0 top
NOREF#3758  -  []  73.56 77.22 0 top
NOREF#3759  -  []  65.23 188.16 90 top
NOREF#3760  -  []  53.07 27.56 0 top
NOREF#3761  -  []  19.76 73.2 0 top
NOREF#3762  -  []  66.88 27.06 0 top
NOREF#3763  -  []  63.53 75.25 0 top
NOREF#3764  -  []  53.85 113.03 270 top
NOREF#3765  -  []  125.7 72.31 270 top
NOREF#3766  -  []  30.56 36.72 0 top
NOREF#3767  -  []  104.01 17.44 90 top
NOREF#3768  -  []  57.48 73.46 0 top
NOREF#3769  -  []  142.8 99.19 0 top
NOREF#3770  -  []  62.97 61.16 0 top
NOREF#3771  -  []  76.1 108.61 90 top
NOREF#3772  -  []  128.56 174.24 0 top
NOREF#3773  -  []  44.15 35.51 90 top
NOREF#3774  -  []  40.64 18.41 90 top
NOREF#3775  -  []  151.77 101.88 90 top
NOREF#3776  -  []  149.87 189.45 270 top
NOREF#3777  -  []  17.98 32.63 90 top
NOREF#3778  -  []  49.35 107.24 0 top
NOREF#3779  -  []  89.65 30.48 0 top
NOREF#3780  -  []  68.28 181.94 0 top
NOREF#3781  -  []  142.82 101.8 0 top
NOREF#3782  -  []  157.05 184.29 0 top
NOREF#3783  -  []  94.11 91.43 90 top
NOREF#3784  -  []  28.69 37.39 0 top
NOREF#3785  -  []  89.28 31.51 0 top
NOREF#3786  -  []  135.67 89.41 90 top
NOREF#3787  -  []  151.08 72.34 90 top
NOREF#3788  -  []  96.58 25.65 0 top
NOREF#3789  -  []  138.76 29.96 0 top
NOREF#3790  -  []  65.18 156.97 0 top
NOREF#3791  -  []  136.14 56.29 90 top
NOREF#3792  -  []  6.12 68.69 270 top
NOREF#3793  -  []  70.94 28.33 270 top
NOREF#3794  -  []  140.28 50.24 90 top
NOREF#3795  -  []  55.37 72.17 90 top
NOREF#3796  -  []  140.07 27.3 0 top
NOREF#3797  -  []  17.35 106.12 90 top
NOREF#3798  -  []  63.25 176.78 0 top
NOREF#3799  -  []  124.87 2.26 0 top
NOREF#3800  -  []  6.6 72.03 90 top
NOREF#3801  -  []  52.65 73.46 0 top
NOREF#3802  -  []  83.93 33.78 0 top
NOREF#3803  -  []  145.59 120.22 90 top
NOREF#3804  -  []  15.95 109.19 90 top
NOREF#3805  -  []  128.51 25.6 90 top
NOREF#3806  -  []  93.5 177.16 0 top
NOREF#3807  -  []  140.82 61.65 0 top
NOREF#3808  -  []  127.99 65.86 0 top
NOREF#3809  -  []  125.12 130.18 0 top
NOREF#3810  -  []  133.22 175.01 90 top
NOREF#3811  -  []  17.27 109.22 90 top
NOREF#3812  -  []  100.28 29.07 0 top
NOREF#3813  -  []  43.83 36.02 90 top
NOREF#3814  -  []  37.07 25.22 0 top
NOREF#3815  -  []  88.87 0.16 0 top
NOREF#3816  -  []  140.28 45.8 90 top
NOREF#3817  -  []  85.17 102.41 270 top
NOREF#3818  -  []  156.7 55.37 90 top
NOREF#3819  -  []  98.6 96.61 0 top
NOREF#3820  -  []  50.7 74.19 0 top
NOREF#3821  -  []  107.94 28.19 0 top
NOREF#3822  -  []  30.43 31.45 0 top
NOREF#3823  -  []  109.72 26.54 0 top
NOREF#3824  -  []  126.19 30.37 270 top
NOREF#3825  -  []  127.53 66.57 0 top
NOREF#3826  -  []  63.96 175.59 90 top
NOREF#3827  -  []  147.96 129.79 90 top
NOREF#3828  -  []  48.03 73.53 270 top
NOREF#3829  -  []  130 36.58 90 top
NOREF#3830  -  []  67.03 104.09 0 top
NOREF#3831  -  []  49.35 109.56 270 top
NOREF#3832  -  []  67.81 89.57 0 top
NOREF#3833  -  []  50.44 53.11 0 top
NOREF#3834  -  []  118.06 43.28 0 top
NOREF#3835  -  []  18.02 30.48 0 top
NOREF#3836  -  []  65.84 80.42 0 top
NOREF#3837  -  []  121.08 30.3 90 top
NOREF#3838  -  []  65.05 51.33 0 top
NOREF#3839  -  []  72.57 81.66 0 top
NOREF#3840  -  []  57.78 58.25 270 top
NOREF#3841  -  []  93.04 190.7 90 top
NOREF#3842  -  []  51.61 101.8 0 top
NOREF#3843  -  []  137.03 34.86 270 top
NOREF#3844  -  []  129.48 54.87 90 top
NOREF#3845  -  []  127.64 73.66 0 top
NOREF#3846  -  []  34.75 30.62 270 top
NOREF#3847  -  []  138.58 107.28 90 top
NOREF#3848  -  []  134.4 146.05 0 top
NOREF#3849  -  []  65.66 176.05 90 top
NOREF#3850  -  []  87.41 92.19 90 top
NOREF#3851  -  []  17.3 114.58 90 top
NOREF#3852  -  []  45.42 26.71 0 top
NOREF#3853  -  []  157 176.91 0 top
NOREF#3854  -  []  146.13 128.09 0 top
NOREF#3855  -  []  138.8 34.16 0 top
NOREF#3856  -  []  123.49 182.04 270 top
NOREF#3857  -  []  53.2 36.63 270 top
NOREF#3858  -  []  129.67 134.14 90 top
NOREF#3859  -  []  42.27 81.33 0 top
NOREF#3860  -  []  74.98 80.06 270 top
NOREF#3861  -  []  100.66 18.72 0 top
NOREF#3862  -  []  8.38 109.37 90 top
NOREF#3863  -  []  135.41 103.38 0 top
NOREF#3864  -  []  38.34 23.8 0 top
NOREF#3865  -  []  65.91 31.58 270 top
NOREF#3866  -  []  5.87 83.72 90 top
NOREF#3867  -  []  142.57 122.15 0 top
NOREF#3868  -  []  134.86 56.59 0 top
NOREF#3869  -  []  71.32 32.4 270 top
NOREF#3870  -  []  138.8 32.89 0 top
NOREF#3871  -  []  17.91 36.44 90 top
NOREF#3872  -  []  129.24 163.5 0 top
NOREF#3873  -  []  150.57 179.25 270 top
NOREF#3874  -  []  136.89 34.9 0 top
NOREF#3875  -  []  69.6 82.91 270 top
NOREF#3876  -  []  141.99 26.16 90 top
NOREF#3877  -  []  34.75 31.76 270 top
NOREF#3878  -  []  44.17 94.02 270 top
NOREF#3879  -  []  118.75 153.92 270 top
NOREF#3880  -  []  157 177.93 0 top
NOREF#3881  -  []  89.31 105.79 0 top
NOREF#3882  -  []  139.27 178.77 0 top
NOREF#3883  -  []  130.56 24.14 270 top
NOREF#3884  -  []  120.88 44.15 90 top
NOREF#3885  -  []  129.29 24.14 270 top
NOREF#3886  -  []  53.85 73.46 0 top
NOREF#3887  -  []  88.27 33.52 90 top
NOREF#3888  -  []  30.18 36.53 270 top
NOREF#3889  -  []  115.57 34.43 270 top
NOREF#3890  -  []  34.79 29.84 0 top
NOREF#3891  -  []  96.77 17.4 90 top
NOREF#3892  -  []  46.46 58.52 0 top
NOREF#3893  -  []  126.19 32.14 270 top
NOREF#3894  -  []  36.56 26.54 0 top
NOREF#3895  -  []  85.01 93.12 0 top
NOREF#3896  -  []  49.2 26.78 90 top
NOREF#3897  -  []  98.4 102.16 0 top
NOREF#3898  -  []  60.53 69.52 0 top
NOREF#3899  -  []  63.63 17.44 90 top
NOREF#3900  -  []  86.44 92.41 270 top
NOREF#3901  -  []  135 130.3 90 top
NOREF#3902  -  []  69.42 108.48 270 top
NOREF#3903  -  []  130.68 44.07 90 top
NOREF#3904  -  []  130.63 126.29 0 top
NOREF#3905  -  []  127.18 140.03 90 top
NOREF#3906  -  []  98.78 106.22 0 top
NOREF#3907  -  []  27.38 38.43 90 top
NOREF#3908  -  []  102.25 97.13 90 top
NOREF#3909  -  []  56.57 72.17 90 top
NOREF#3910  -  []  57.48 56.97 0 top
NOREF#3911  -  []  156.84 176.91 0 top
NOREF#3912  -  []  150.88 179.2 0 top
NOREF#3913  -  []  107.9 28.33 270 top
NOREF#3914  -  []  126.57 52.95 90 top
NOREF#3915  -  []  20.19 72.75 270 top
NOREF#3916  -  []  62.15 69.52 270 top
NOREF#3917  -  []  34.91 36.63 0 top
NOREF#3918  -  []  65.56 67.06 0 top
NOREF#3919  -  []  66.07 79.96 0 top
NOREF#3920  -  []  150.88 178.05 0 top
NOREF#3921  -  []  131.33 42.24 90 top
NOREF#3922  -  []  31.19 192.61 0 top
NOREF#3923  -  []  67.49 26.78 90 top
NOREF#3924  -  []  94.6 91.39 90 top
NOREF#3925  -  []  146.81 112.65 0 top
NOREF#3926  -  []  121.67 171.45 270 top
NOREF#3927  -  []  56.01 173.9 90 top
NOREF#3928  -  []  61.59 102.12 270 top
NOREF#3929  -  []  150.57 191.08 0 top
NOREF#3930  -  []  49.61 142.7 0 top
NOREF#3931  -  []  53.85 71.83 90 top
NOREF#3932  -  []  134 34.92 270 top
NOREF#3933  -  []  112.52 12.4 270 top
NOREF#3934  -  []  76.14 197.59 90 top
NOREF#3935  -  []  146.74 179.25 270 top
NOREF#3936  -  []  144.86 177.09 0 top
NOREF#3937  -  []  83.52 31.72 90 top
NOREF#3938  -  []  82.5 56.79 0 top
NOREF#3939  -  []  118.36 18.41 90 top
NOREF#3940  -  []  111.2 159.18 270 top
NOREF#3941  -  []  140.54 128.07 0 top
NOREF#3942  -  []  46.76 108.99 0 top
NOREF#3943  -  []  132.51 54.56 90 top
NOREF#3944  -  []  70.94 28.05 0 top
NOREF#3945  -  []  100.13 64.59 90 top
NOREF#3946  -  []  138.76 33.67 0 top
NOREF#3947  -  []  107.9 30.34 0 top
NOREF#3948  -  []  141.78 104.19 270 top
NOREF#3949  -  []  139.12 102.67 270 top
NOREF#3950  -  []  141.17 174.96 0 top
NOREF#3951  -  []  127.53 66.57 90 top
NOREF#3952  -  []  63.32 18.72 0 top
NOREF#3953  -  []  134.4 148.97 0 top
NOREF#3954  -  []  32.44 29.71 90 top
NOREF#3955  -  []  18.59 30.34 90 top
NOREF#3956  -  []  56.46 98.12 0 top
NOREF#3957  -  []  109.68 29.07 0 top
NOREF#3958  -  []  149.17 73.84 0 top
NOREF#3959  -  []  135.59 35.89 0 top
NOREF#3960  -  []  17.22 66.75 0 top
NOREF#3961  -  []  27.94 6.91 90 top
NOREF#3962  -  []  17.65 39.51 270 top
NOREF#3963  -  []  76.15 37.2 90 top
NOREF#3964  -  []  111.35 151.33 0 top
NOREF#3965  -  []  120.75 104.7 0 top
NOREF#3966  -  []  121.78 26.92 0 top
NOREF#3967  -  []  67.01 65.48 90 top
NOREF#3968  -  []  91.64 99.91 90 top
NOREF#3969  -  []  19.99 38.43 90 top
NOREF#3970  -  []  121.08 28.69 90 top
NOREF#3971  -  []  97.42 34.47 270 top
NOREF#3972  -  []  89.65 27.56 0 top
NOREF#3973  -  []  37.34 36.31 90 top
NOREF#3974  -  []  95.61 57.61 0 top
NOREF#3975  -  []  153.21 122.22 270 top
NOREF#3976  -  []  137.69 42.16 270 top
NOREF#3977  -  []  27.55 194.36 90 top
NOREF#3978  -  []  98.17 17.4 90 top
NOREF#3979  -  []  103 60.92 270 top
NOREF#3980  -  []  73.14 30.61 0 top
NOREF#3981  -  []  24.71 66.75 0 top
NOREF#3982  -  []  98.3 139.42 270 top
NOREF#3983  -  []  53.04 29.71 0 top
NOREF#3984  -  []  20.37 31.99 90 top
NOREF#3985  -  []  93.97 91.39 90 top
NOREF#3986  -  []  150.7 21.82 0 top
NOREF#3987  -  []  138.38 176.7 0 top
NOREF#3988  -  []  124.45 44.7 0 top
NOREF#3989  -  []  140.87 107.24 90 top
NOREF#3990  -  []  122.56 73.86 90 top
NOREF#3991  -  []  136.88 89.97 0 top
NOREF#3992  -  []  118.97 24.99 90 top
NOREF#3993  -  []  70.94 29.98 270 top
NOREF#3994  -  []  91.07 100.05 0 top
NOREF#3995  -  []  75.01 99.75 0 top
NOREF#3996  -  []  145.44 188.59 0 top
NOREF#3997  -  []  121.36 133.05 0 top
NOREF#3998  -  []  54.99 40.49 270 top
NOREF#3999  -  []  128.57 27.06 270 top
NOREF#4000  -  []  20.4 77.77 0 top
NOREF#4001  -  []  134.37 145.8 0 top
NOREF#4002  -  []  7.69 170.56 90 top
NOREF#4003  -  []  43.04 34.47 0 top
NOREF#4004  -  []  151.59 147.65 0 top
NOREF#4005  -  []  94.69 17.09 90 top
NOREF#4006  -  []  123.9 18.72 0 top
NOREF#4007  -  []  84.07 18.41 90 top
NOREF#4008  -  []  53.29 77.85 270 top
NOREF#4009  -  []  48.59 27.7 270 top
NOREF#4010  -  []  67.81 89.57 90 top
NOREF#4011  -  []  16.48 106.12 0 top
NOREF#4012  -  []  75.69 23.76 270 top
NOREF#4013  -  []  126.9 154.18 0 top
NOREF#4014  -  []  94.12 99.43 90 top
NOREF#4015  -  []  140.03 182.83 0 top
NOREF#4016  -  []  133.36 93.04 90 top
NOREF#4017  -  []  110.63 36.27 90 top
NOREF#4018  -  []  13.28 80.21 90 top
NOREF#4019  -  []  152.8 98.84 0 top
NOREF#4020  -  []  48.9 76.07 270 top
NOREF#4021  -  []  127.99 67.01 0 top
NOREF#4022  -  []  127.89 143.5 270 top
NOREF#4023  -  []  85.72 110.21 270 top
NOREF#4024  -  []  61.49 181.88 90 top
NOREF#4025  -  []  19.8 34.29 0 top
NOREF#4026  -  []  141.33 75.85 270 top
NOREF#4027  -  []  84.51 28.33 270 top
NOREF#4028  -  []  47.22 109.42 0 top
NOREF#4029  -  []  150.57 180.39 270 top
NOREF#4030  -  []  145 109.21 270 top
NOREF#4031  -  []  138.91 40.21 0 top
NOREF#4032  -  []  110.86 23.8 0 top
NOREF#4033  -  []  110.22 23.8 270 top
NOREF#4034  -  []  135.43 49.01 90 top
NOREF#4035  -  []  129.69 163.07 0 top
NOREF#4036  -  []  145.44 187.45 0 top
NOREF#4037  -  []  66.88 27.42 0 top
NOREF#4038  -  []  98.5 65.2 0 top
NOREF#4039  -  []  138.81 83.95 90 top
NOREF#4040  -  []  117.98 34.48 270 top
NOREF#4041  -  []  138.56 83.99 90 top
NOREF#4042  -  []  34.75 30.34 0 top
NOREF#4043  -  []  12.22 117.73 0 top
NOREF#4044  -  []  121.23 76.4 90 top
NOREF#4045  -  []  51.77 142.7 0 top
NOREF#4046  -  []  19 81.61 270 top
NOREF#4047  -  []  149.66 71.63 0 top
NOREF#4048  -  []  98.81 34.43 270 top
NOREF#4049  -  []  59.75 101.51 0 top
NOREF#4050  -  []  59.45 113.37 270 top
NOREF#4051  -  []  134.49 36.97 270 top
NOREF#4052  -  []  126.52 49.78 0 top
NOREF#4053  -  []  85.51 102.11 0 top
NOREF#4054  -  []  144.09 100.51 270 top
NOREF#4055  -  []  139.88 101.47 0 top
NOREF#4056  -  []  124.41 45.48 0 top
NOREF#4057  -  []  41 90.27 90 top
NOREF#4058  -  []  144.98 187.88 0 top
NOREF#4059  -  []  51.05 78.36 270 top
NOREF#4060  -  []  136.89 27.99 0 top
NOREF#4061  -  []  85.78 27.06 270 top
NOREF#4062  -  []  102.18 28.97 0 top
NOREF#4063  -  []  126.19 28.08 0 top
NOREF#4064  -  []  107.01 37.96 90 top
NOREF#4065  -  []  137.27 44.7 0 top
NOREF#4066  -  []  65.65 33.15 0 top
NOREF#4067  -  []  55.12 58.29 270 top
NOREF#4068  -  []  54.1 58.25 270 top
NOREF#4069  -  []  65.66 33.15 270 top
NOREF#4070  -  []  138.91 74.88 0 top
NOREF#4071  -  []  21.39 117.6 0 top
NOREF#4072  -  []  128.22 174.55 270 top
NOREF#4073  -  []  126.57 50.53 90 top
NOREF#4074  -  []  18.95 131.95 0 top
NOREF#4075  -  []  62.18 51.38 0 top
NOREF#4076  -  []  34.11 17.09 90 top
NOREF#4077  -  []  34.67 33.52 90 top
NOREF#4078  -  []  56.26 173.86 90 top
NOREF#4079  -  []  124.66 78.28 0 top
NOREF#4080  -  []  76.89 105.46 270 top
NOREF#4081  -  []  61.93 113.37 270 top
NOREF#4082  -  []  115.21 108.97 0 top
NOREF#4083  -  []  55.12 109.52 270 top
NOREF#4084  -  []  45.76 60.83 0 top
NOREF#4085  -  []  140.08 184.15 270 top
NOREF#4086  -  []  36.64 192.23 90 top
NOREF#4087  -  []  65.65 32.51 0 top
NOREF#4088  -  []  121.62 182.04 0 top
NOREF#4089  -  []  100.66 17.09 90 top
NOREF#4090  -  []  142.7 60.78 90 top
NOREF#4091  -  []  89.28 110.24 0 top
NOREF#4092  -  []  44.58 35.97 90 top
NOREF#4093  -  []  124.41 42.05 270 top
NOREF#4094  -  []  95.83 101.78 90 top
NOREF#4095  -  []  93.84 23.8 270 top
NOREF#4096  -  []  89.31 108.84 0 top
NOREF#4097  -  []  133.07 87.43 0 top
NOREF#4098  -  []  45.72 62.48 0 top
NOREF#4099  -  []  43.94 34.43 270 top
NOREF#4100  -  []  71.86 84.38 270 top
NOREF#4101  -  []  120.09 31.72 90 top
NOREF#4102  -  []  126.19 29.35 270 top
NOREF#4103  -  []  144.86 180.29 90 top
NOREF#4104  -  []  124.41 50.41 0 top
NOREF#4105  -  []  38.96 93.93 0 top
NOREF#4106  -  []  50.58 112.03 270 top
NOREF#4107  -  []  67.31 85.05 270 top
NOREF#4108  -  []  115.01 25.69 90 top
NOREF#4109  -  []  127.19 54.69 90 top
NOREF#4110  -  []  137.11 87.96 90 top
NOREF#4111  -  []  41 90.27 0 top
NOREF#4112  -  []  39.45 66.47 270 top
NOREF#4113  -  []  43.18 34.43 270 top
NOREF#4114  -  []  53.59 146.22 90 top
NOREF#4115  -  []  76.02 18.72 270 top
NOREF#4116  -  []  83.9 29.86 270 top
NOREF#4117  -  []  15.82 80.62 90 top
NOREF#4118  -  []  130.63 142.29 270 top
NOREF#4119  -  []  56.39 17.4 90 top
NOREF#4120  -  []  28.97 36.78 90 top
NOREF#4121  -  []  144.7 106.1 270 top
NOREF#4122  -  []  141.43 106.93 90 top
NOREF#4123  -  []  127.2 75.77 0 top
NOREF#4124  -  []  115.98 122.17 0 top
NOREF#4125  -  []  13.72 80.67 90 top
NOREF#4126  -  []  12.45 108.86 90 top
NOREF#4127  -  []  76.71 37.52 270 top
NOREF#4128  -  []  56.58 113.07 270 top
NOREF#4129  -  []  120.47 31.93 0 top
NOREF#4130  -  []  16.92 106.58 90 top
NOREF#4131  -  []  111.81 151.76 0 top
NOREF#4132  -  []  107.94 28.83 0 top
NOREF#4133  -  []  92 27.44 270 top
NOREF#4134  -  []  47.78 54.38 0 top
NOREF#4135  -  []  121.16 170.43 90 top
NOREF#4136  -  []  6.96 110.95 0 top
NOREF#4137  -  []  137.03 76.07 0 top
NOREF#4138  -  []  55.07 71.83 90 top
NOREF#4139  -  []  134.4 151.26 0 top
NOREF#4140  -  []  28.75 29.79 0 top
NOREF#4141  -  []  10.01 123.39 0 top
NOREF#4142  -  []  45.45 27.61 0 top
NOREF#4143  -  []  8.38 110.52 90 top
NOREF#4144  -  []  140.82 106.93 90 top
NOREF#4145  -  []  126.01 54.43 90 top
NOREF#4146  -  []  126.9 155.45 0 top
NOREF#4147  -  []  143.28 104.52 0 top
NOREF#4148  -  []  49.78 53.98 270 top
NOREF#4149  -  []  92.08 23.76 270 top
NOREF#4150  -  []  63.74 34.52 0 top
NOREF#4151  -  []  77.53 26.26 270 top
NOREF#4152  -  []  145.31 176.66 0 top
NOREF#4153  -  []  111.71 36.2 90 top
NOREF#4154  -  []  81.86 35.51 0 top
NOREF#4155  -  []  61.85 82.93 90 top
NOREF#4156  -  []  141.91 134.92 270 top
NOREF#4157  -  []  111.66 37.52 0 top
NOREF#4158  -  []  43.46 68.33 0 top
NOREF#4159  -  []  105.41 25.78 90 top
NOREF#4160  -  []  57.96 98.12 0 top
NOREF#4161  -  []  10.46 123.83 0 top
NOREF#4162  -  []  57.53 109.56 270 top
NOREF#4163  -  []  31.17 35.17 90 top
NOREF#4164  -  []  145.71 107.79 0 top
NOREF#4165  -  []  131.27 176.61 0 top
NOREF#4166  -  []  89.79 107.31 90 top
NOREF#4167  -  []  119.08 181.03 0 top
NOREF#4168  -  []  135.31 184.45 270 top
NOREF#4169  -  []  17.13 36.4 90 top
NOREF#4170  -  []  55.19 54.56 0 top
NOREF#4171  -  []  132.05 73.71 270 top
NOREF#4172  -  []  64.16 76.73 90 top
NOREF#4173  -  []  21.79 25.97 90 top
NOREF#4174  -  []  99.79 95.36 90 top
NOREF#4175  -  []  6.3 154.25 90 top
NOREF#4176  -  []  82.91 53.54 0 top
NOREF#4177  -  []  138.94 30.33 270 top
NOREF#4178  -  []  99.01 138 0 top
NOREF#4179  -  []  122.22 182.04 270 top
NOREF#4180  -  []  153.3 100.96 0 top
NOREF#4181  -  []  80.12 36.02 0 top
NOREF#4182  -  []  138.13 41.71 270 top
NOREF#4183  -  []  140.15 177.66 270 top
NOREF#4184  -  []  125.81 76.4 0 top
NOREF#4185  -  []  108.96 138.44 90 top
NOREF#4186  -  []  54.15 72.17 90 top
NOREF#4187  -  []  77.67 26.23 270 top
NOREF#4188  -  []  79.9 33.86 90 top
NOREF#4189  -  []  150.57 176.96 270 top
NOREF#4190  -  []  32.08 36.37 0 top
NOREF#4191  -  []  65.1 67.77 90 top
NOREF#4192  -  []  111.49 23.8 0 top
NOREF#4193  -  []  31.17 35.8 90 top
NOREF#4194  -  []  64.11 24.99 90 top
NOREF#4195  -  []  119.38 180.47 0 top
NOREF#4196  -  []  115.42 87.71 0 top
NOREF#4197  -  []  124.79 135.31 0 top
NOREF#4198  -  []  60.16 91.68 270 top
NOREF#4199  -  []  97.47 25.65 90 top
NOREF#4200  -  []  37.07 23.8 0 top
NOREF#4201  -  []  93.04 176.73 90 top
NOREF#4202  -  []  74.8 18.38 270 top
NOREF#4203  -  []  133.3 26.07 90 top
NOREF#4204  -  []  43.31 112.52 270 top
NOREF#4205  -  []  126.7 139.62 0 top
NOREF#4206  -  []  6.97 108.66 0 top
NOREF#4207  -  []  56.16 78.16 0 top
NOREF#4208  -  []  66.29 85.05 270 top
NOREF#4209  -  []  28.07 28.6 90 top
NOREF#4210  -  []  27.81 38.89 90 top
NOREF#4211  -  []  120.78 30.65 90 top
NOREF#4212  -  []  149.17 66.85 270 top
NOREF#4213  -  []  58.04 73.14 90 top
NOREF#4214  -  []  75.46 103.89 0 top
NOREF#4215  -  []  130.72 173.1 0 top
NOREF#4216  -  []  91.39 27.17 0 top
NOREF#4217  -  []  63.56 75.39 0 top
NOREF#4218  -  []  142.88 70.57 270 top
NOREF#4219  -  []  48.41 139.57 0 top
NOREF#4220  -  []  54.85 30.61 0 top
NOREF#4221  -  []  134.06 148.67 90 top
NOREF#4222  -  []  49.35 104.09 0 top
NOREF#4223  -  []  134.06 149.91 0 top
NOREF#4224  -  []  30.59 35.31 0 top
NOREF#4225  -  []  104.72 138 90 top
NOREF#4226  -  []  67.69 83.82 270 top
NOREF#4227  -  []  54.91 168.35 90 top
NOREF#4228  -  []  118.44 35.51 90 top
NOREF#4229  -  []  136.22 64.06 0 top
NOREF#4230  -  []  125.73 181.7 270 top
NOREF#4231  -  []  66.57 103.66 0 top
NOREF#4232  -  []  139.06 31.03 90 top
NOREF#4233  -  []  142.52 99.09 90 top
NOREF#4234  -  []  61.46 101.55 0 top
NOREF#4235  -  []  18.03 109.26 90 top
NOREF#4236  -  []  64.87 2.26 0 top
NOREF#4237  -  []  71.32 31.48 0 top
NOREF#4238  -  []  49.35 105.99 270 top
NOREF#4239  -  []  71.02 25.84 0 top
NOREF#4240  -  []  131.09 72.39 90 top
NOREF#4241  -  []  120.65 29.95 270 top
NOREF#4242  -  []  53.04 30.34 0 top
NOREF#4243  -  []  139.27 90.09 270 top
NOREF#4244  -  []  58.99 113.07 270 top
NOREF#4245  -  []  12.67 81.61 0 top
NOREF#4246  -  []  137.16 17.4 90 top
NOREF#4247  -  []  45.72 63.25 90 top
NOREF#4248  -  []  34.06 190.91 90 top
NOREF#4249  -  []  144.86 175.95 0 top
NOREF#4250  -  []  62.17 91.68 0 top
NOREF#4251  -  []  123.85 70.89 90 top
NOREF#4252  -  []  45.2 45.67 0 top
NOREF#4253  -  []  38.56 37.2 90 top
NOREF#4254  -  []  42.33 184.31 0 top
NOREF#4255  -  []  74.28 23.8 270 top
NOREF#4256  -  []  36.56 30.61 0 top
NOREF#4257  -  []  148.82 130.77 270 top
NOREF#4258  -  []  130.58 173.46 0 top
NOREF#4259  -  []  138.94 120.76 90 top
NOREF#4260  -  []  144.98 189.03 0 top
NOREF#4261  -  []  127.36 72.95 0 top
NOREF#4262  -  []  141.35 17.44 90 top
NOREF#4263  -  []  136.53 184.11 270 top
NOREF#4264  -  []  30.61 33.4 90 top
NOREF#4265  -  []  66.87 5.46 270 top
NOREF#4266  -  []  149.66 74.3 0 top
NOREF#4267  -  []  151.78 101.89 270 top
NOREF#4268  -  []  91.39 30.75 0 top
NOREF#4269  -  []  140.16 138.76 90 top
NOREF#4270  -  []  19.76 73.2 270 top
NOREF#4271  -  []  15.06 20.82 90 top
NOREF#4272  -  []  128.64 73.66 90 top
NOREF#4273  -  []  119.08 135.2 90 top
NOREF#4274  -  []  18.19 67.89 0 top
NOREF#4275  -  []  64.71 91.68 0 top
NOREF#4276  -  []  30.56 34.72 0 top
NOREF#4277  -  []  42.97 101.97 90 top
NOREF#4278  -  []  67.71 178.58 90 top
NOREF#4279  -  []  101.93 25.73 90 top
NOREF#4280  -  []  53.75 78.16 0 top
NOREF#4281  -  []  44.17 102.77 90 top
NOREF#4282  -  []  63.37 109.52 270 top
NOREF#4283  -  []  27.04 37.39 0 top
NOREF#4284  -  []  141.6 149.52 90 top
NOREF#4285  -  []  149.66 68.96 0 top
NOREF#4286  -  []  123.95 154.31 270 top
NOREF#4287  -  []  111.02 128.02 0 top
NOREF#4288  -  []  53.04 32.4 270 top
NOREF#4289  -  []  125.55 154.74 0 top
NOREF#4290  -  []  123.39 64.96 90 top
NOREF#4291  -  []  148.59 193.8 90 top
NOREF#4292  -  []  94.59 106.98 0 top
NOREF#4293  -  []  133.74 44.63 270 top
NOREF#4294  -  []  43.13 17.09 90 top
NOREF#4295  -  []  102.69 59.64 0 top
NOREF#4296  -  []  36.53 29.07 0 top
NOREF#4297  -  []  47.68 145.11 90 top
NOREF#4298  -  []  58.53 98.89 270 top
NOREF#4299  -  []  101.8 31.72 90 top
NOREF#4300  -  []  138.51 28.91 0 top
NOREF#4301  -  []  76.02 52.24 270 top
NOREF#4302  -  []  61.79 59.39 90 top
NOREF#4303  -  []  89.32 109.98 0 top
NOREF#4304  -  []  117.81 17.09 90 top
NOREF#4305  -  []  9.07 77.93 90 top
NOREF#4306  -  []  134.49 131.32 270 top
NOREF#4307  -  []  62.94 188.16 0 top
NOREF#4308  -  []  61.46 102.16 270 top
NOREF#4309  -  []  46.89 76.07 0 top
NOREF#4310  -  []  106.69 33.48 90 top
NOREF#4311  -  []  42.88 108.69 90 top
NOREF#4312  -  []  30.61 28.71 90 top
NOREF#4313  -  []  102.23 32.18 90 top
NOREF#4314  -  []  99.16 95.45 90 top
NOREF#4315  -  []  65.23 33.6 0 top
NOREF#4316  -  []  96.22 18.72 0 top
NOREF#4317  -  []  121.69 73.86 0 top
NOREF#4318  -  []  138.8 29.21 0 top
NOREF#4319  -  []  115.82 122.58 90 top
NOREF#4320  -  []  51.64 73.46 0 top
NOREF#4321  -  []  144.83 127.91 270 top
NOREF#4322  -  []  25.07 28.59 90 top
NOREF#4323  -  []  68.4 56.95 270 top
NOREF#4324  -  []  123.65 43.38 90 top
NOREF#4325  -  []  132.21 42.28 90 top
NOREF#4326  -  []  140.28 47.19 90 top
NOREF#4327  -  []  11.84 22.1 0 top
NOREF#4328  -  []  82.75 51.42 90 top
NOREF#4329  -  []  64.01 35.97 90 top
NOREF#4330  -  []  126.35 34.03 90 top
NOREF#4331  -  []  60.27 17.09 90 top
NOREF#4332  -  []  120.04 103.28 90 top
NOREF#4333  -  []  125.86 32.52 90 top
NOREF#4334  -  []  107.9 26.43 270 top
NOREF#4335  -  []  111.71 37.2 90 top
NOREF#4336  -  []  129.67 44.06 90 top
NOREF#4337  -  []  45.92 146.99 0 top
NOREF#4338  -  []  124.21 17.44 90 top
NOREF#4339  -  []  52.65 71.83 90 top
NOREF#4340  -  []  39.45 61.8 0 top
NOREF#4341  -  []  27.94 12.5 0 top
NOREF#4342  -  []  34.81 33.48 90 top
NOREF#4343  -  []  156.41 192.33 0 top
NOREF#4344  -  []  115.9 25.69 90 top
NOREF#4345  -  []  48.92 56.26 0 top
NOREF#4346  -  []  96.72 25.69 90 top
NOREF#4347  -  []  38.51 101.73 0 top
NOREF#4348  -  []  48.13 12.5 270 top
NOREF#4349  -  []  66.33 97.75 270 top
NOREF#4350  -  []  59.13 83.95 270 top
NOREF#4351  -  []  53.31 47.6 0 top
NOREF#4352  -  []  89.61 30.62 270 top
NOREF#4353  -  []  46.94 33.6 0 top
NOREF#4354  -  []  101.42 64.06 270 top
NOREF#4355  -  []  60.9 25.63 0 top
NOREF#4356  -  []  41.77 94.24 270 top
NOREF#4357  -  []  61.47 113.07 270 top
NOREF#4358  -  []  53.84 147.19 90 top
NOREF#4359  -  []  108.42 53.16 0 top
NOREF#4360  -  []  119.96 35.1 270 top
NOREF#4361  -  []  85.17 102.41 0 top
NOREF#4362  -  []  122.25 171.75 270 top
NOREF#4363  -  []  20.9 73.2 0 top
NOREF#4364  -  []  2.03 5.84 0 top
NOREF#4365  -  []  35.23 41.45 270 top
NOREF#4366  -  []  58.28 25.63 0 top
NOREF#4367  -  []  128.15 140.47 0 top
NOREF#4368  -  []  75.69 37.52 270 top
NOREF#4369  -  []  136.12 131.62 270 top
NOREF#4370  -  []  100.6 34.52 270 top
NOREF#4371  -  []  68.2 82.8 90 top
NOREF#4372  -  []  15.52 108.74 90 top
NOREF#4373  -  []  151.89 120.78 90 top
NOREF#4374  -  []  7.62 14.1 270 top
NOREF#4375  -  []  134.9 75.21 90 top
NOREF#4376  -  []  33.35 191.36 90 top
NOREF#4377  -  []  78.99 34.43 270 top
NOREF#4378  -  []  16.66 80.16 90 top
NOREF#4379  -  []  40.39 94.36 270 top
NOREF#4380  -  []  136.53 63.5 90 top
NOREF#4381  -  []  147.65 125.81 0 top
NOREF#4382  -  []  146.37 0.56 90 top
NOREF#4383  -  []  134.82 49.01 0 top
NOREF#4384  -  []  128.41 141.66 0 top
NOREF#4385  -  []  97.47 25.65 0 top
NOREF#4386  -  []  141.3 89.36 90 top
NOREF#4387  -  []  75.01 106.6 0 top
NOREF#4388  -  []  141.35 121.84 0 top
NOREF#4389  -  []  21.13 126.44 90 top
NOREF#4390  -  []  63.26 34.52 270 top
NOREF#4391  -  []  65.65 28.19 0 top
NOREF#4392  -  []  136.22 77.93 90 top
NOREF#4393  -  []  107.57 31.51 0 top
NOREF#4394  -  []  137.97 128.07 270 top
NOREF#4395  -  []  143.18 70.92 270 top
NOREF#4396  -  []  39.45 63.07 0 top
NOREF#4397  -  []  24.93 28.55 0 top
NOREF#4398  -  []  47.9 143.13 0 top
NOREF#4399  -  []  65.35 25.73 90 top
NOREF#4400  -  []  34.75 28.33 270 top
NOREF#4401  -  []  82.45 105.19 90 top
NOREF#4402  -  []  74.64 199.29 0 top
NOREF#4403  -  []  107.57 32.14 90 top
NOREF#4404  -  []  27 127.3 0 top
NOREF#4405  -  []  52.18 102.43 90 top
NOREF#4406  -  []  42.56 34.47 270 top
NOREF#4407  -  []  126.61 52.32 0 top
NOREF#4408  -  []  128.32 158.7 90 top
NOREF#4409  -  []  58.22 53.26 270 top
NOREF#4410  -  []  152.91 139.95 90 top
NOREF#4411  -  []  51.69 33.52 90 top
NOREF#4412  -  []  123.95 171.45 270 top
NOREF#4413  -  []  146.96 87.63 90 top
NOREF#4414  -  []  54.86 113.03 270 top
NOREF#4415  -  []  132.79 127.3 0 top
NOREF#4416  -  []  52.15 37.86 0 top
NOREF#4417  -  []  142.04 73.58 270 top
NOREF#4418  -  []  33.38 193.5 0 top
NOREF#4419  -  []  146.25 129.49 0 top
NOREF#4420  -  []  26.28 37.39 0 top
NOREF#4421  -  []  38.56 36.2 90 top
NOREF#4422  -  []  143.89 92.95 90 top
NOREF#4423  -  []  155.53 114.01 90 top
NOREF#4424  -  []  126.95 42.3 0 top
NOREF#4425  -  []  35.03 31.79 270 top
NOREF#4426  -  []  67.06 156.11 90 top
NOREF#4427  -  []  115.39 121.21 0 top
NOREF#4428  -  []  66.57 102.51 0 top
NOREF#4429  -  []  7.44 154.38 90 top
NOREF#4430  -  []  76.58 18.41 90 top
NOREF#4431  -  []  80.77 18.38 270 top
NOREF#4432  -  []  139.57 179.32 0 top
NOREF#4433  -  []  76.89 106.6 270 top
NOREF#4434  -  []  88.52 6.91 90 top
NOREF#4435  -  []  133.16 26.04 0 top
NOREF#4436  -  []  36.4 128.32 270 top
NOREF#4437  -  []  71.03 31.65 0 top
NOREF#4438  -  []  143.75 93.52 0 top
NOREF#4439  -  []  131.19 42.28 90 top
NOREF#4440  -  []  30.61 34.41 90 top
NOREF#4441  -  []  6.5 110.24 0 top
NOREF#4442  -  []  50.06 46.51 0 top
NOREF#4443  -  []  37.13 29.35 270 top
NOREF#4444  -  []  40.39 103.15 90 top
NOREF#4445  -  []  5.56 115.77 270 top
NOREF#4446  -  []  111.63 23.76 270 top
NOREF#4447  -  []  94.59 106.98 270 top
NOREF#4448  -  []  92.34 36.27 90 top
NOREF#4449  -  []  60.2 109.44 270 top
NOREF#4450  -  []  38.81 36.23 90 top
NOREF#4451  -  []  40.39 100.86 90 top
NOREF#4452  -  []  18.02 35.18 0 top
NOREF#4453  -  []  131.57 26.07 90 top
NOREF#4454  -  []  124.58 42.41 0 top
NOREF#4455  -  []  42.21 90.27 90 top
NOREF#4456  -  []  120.78 153.9 270 top
NOREF#4457  -  []  56.39 108.55 90 top
NOREF#4458  -  []  131.6 73.41 270 top
NOREF#4459  -  []  110.44 152.73 0 top
NOREF#4460  -  []  143.28 102.23 0 top
NOREF#4461  -  []  141.48 175.51 0 top
NOREF#4462  -  []  140.03 79.55 0 top
NOREF#4463  -  []  85.47 101.85 0 top
NOREF#4464  -  []  140.61 73.15 0 top
NOREF#4465  -  []  54.76 148.46 0 top
NOREF#4466  -  []  128.91 141.57 90 top
NOREF#4467  -  []  56.89 75.68 90 top
NOREF#4468  -  []  60.48 59.94 0 top
NOREF#4469  -  []  127.53 65.43 90 top
NOREF#4470  -  []  45.42 60.53 0 top
NOREF#4471  -  []  31.86 30.48 0 top
NOREF#4472  -  []  75.01 100.89 0 top
NOREF#4473  -  []  113.08 159.46 90 top
NOREF#4474  -  []  145.31 175.51 0 top
NOREF#4475  -  []  45.42 66.75 0 top
NOREF#4476  -  []  65.1 67.77 0 top
NOREF#4477  -  []  34.49 37.99 0 top
NOREF#4478  -  []  100.38 93.93 0 top
NOREF#4479  -  []  132.21 54.85 90 top
NOREF#4480  -  []  149.66 127.69 270 top
NOREF#4481  -  []  63.96 91.11 90 top
NOREF#4482  -  []  56.21 54.56 0 top
NOREF#4483  -  []  66.84 101.05 0 top
NOREF#4484  -  []  30.3 29.26 0 top
NOREF#4485  -  []  82.03 27.61 0 top
NOREF#4486  -  []  65.48 51.79 90 top
NOREF#4487  -  []  149.66 74.3 0 top
NOREF#4488  -  []  100.63 110.79 270 top
NOREF#4489  -  []  83.64 26.34 270 top
NOREF#4490  -  []  56.43 98.26 0 top
NOREF#4491  -  []  139.4 126.19 0 top
NOREF#4492  -  []  75.55 23.8 0 top
NOREF#4493  -  []  138.25 126.19 0 top
NOREF#4494  -  []  47.71 112.08 270 top
NOREF#4495  -  []  26.42 37.35 270 top
NOREF#4496  -  []  22.12 164.08 0 top
NOREF#4497  -  []  149.07 129.79 90 top
NOREF#4498  -  []  65.58 65.91 0 top
NOREF#4499  -  []  139.6 107.24 90 top
NOREF#4500  -  []  120.85 17.09 90 top
NOREF#4501  -  []  128.61 41.91 0 top
NOREF#4502  -  []  53.92 76 270 top
NOREF#4503  -  []  35.33 192.79 0 top
NOREF#4504  -  []  49.86 72.17 90 top
NOREF#4505  -  []  128.32 157.43 90 top
NOREF#4506  -  []  67.18 82.8 90 top
NOREF#4507  -  []  137.46 28.13 270 top
NOREF#4508  -  []  55.4 167.13 0 top
NOREF#4509  -  []  157.42 111 0 top
NOREF#4510  -  []  139.98 89.92 0 top
NOREF#4511  -  []  136.6 90.09 270 top
NOREF#4512  -  []  121.08 30.4 270 top
NOREF#4513  -  []  64.85 91.64 270 top
NOREF#4514  -  []  124.45 45.34 0 top
NOREF#4515  -  []  90.53 98.86 90 top
NOREF#4516  -  []  141 127.64 0 top
NOREF#4517  -  []  19.75 25.93 90 top
NOREF#4518  -  []  63.58 35.51 0 top
NOREF#4519  -  []  89.61 31.48 0 top
NOREF#4520  -  []  90.09 107.37 0 top
NOREF#4521  -  []  62.1 60.96 270 top
NOREF#4522  -  []  71.63 36.59 270 top
NOREF#4523  -  []  16.26 107.21 90 top
NOREF#4524  -  []  68.45 83.78 270 top
NOREF#4525  -  []  21.02 25.93 90 top
NOREF#4526  -  []  119.61 104.7 0 top
NOREF#4527  -  []  53.75 78.16 270 top
NOREF#4528  -  []  129.78 24.18 270 top
NOREF#4529  -  []  87.66 93.5 90 top
NOREF#4530  -  []  110.03 70.11 90 top
NOREF#4531  -  []  61.19 71.45 0 top
NOREF#4532  -  []  31.17 33.1 90 top
NOREF#4533  -  []  152.63 87.58 90 top
NOREF#4534  -  []  134.85 88.09 90 top
NOREF#4535  -  []  108.58 153.42 0 top
NOREF#4536  -  []  59.75 102.12 270 top
NOREF#4537  -  []  75.01 102.69 0 top
NOREF#4538  -  []  53.67 54.43 0 top
NOREF#4539  -  []  65.61 33.92 0 top
NOREF#4540  -  []  76.14 197.59 0 top
NOREF#4541  -  []  150.88 191.64 0 top
NOREF#4542  -  []  54.78 146.18 0 top
NOREF#4543  -  []  11.25 80.67 90 top
NOREF#4544  -  []  9.98 109.32 90 top
NOREF#4545  -  []  110.86 23.8 270 top
NOREF#4546  -  []  58.08 103.59 0 top
NOREF#4547  -  []  63.7 26.71 0 top
NOREF#4548  -  []  57.66 75.65 270 top
NOREF#4549  -  []  48.16 57.25 90 top
NOREF#4550  -  []  46.2 73.66 0 top
NOREF#4551  -  []  50.52 49.35 0 top
NOREF#4552  -  []  117.23 34.47 270 top
NOREF#4553  -  []  125.48 34.43 270 top
NOREF#4554  -  []  73.18 55.75 270 top
NOREF#4555  -  []  133.25 126.87 0 top
NOREF#4556  -  []  27.06 38.81 90 top
NOREF#4557  -  []  16.76 109.22 90 top
NOREF#4558  -  []  11.2 126.39 90 top
NOREF#4559  -  []  150.67 114.43 0 top
NOREF#4560  -  []  134.4 149.61 0 top
NOREF#4561  -  []  26.87 0.16 90 top
NOREF#4562  -  []  134.62 52.88 0 top
NOREF#4563  -  []  44.15 35.51 0 top
NOREF#4564  -  []  49.56 74.19 0 top
NOREF#4565  -  []  68.17 79.96 0 top
NOREF#4566  -  []  116.22 108.97 90 top
NOREF#4567  -  []  45.76 67.06 0 top
NOREF#4568  -  []  139.12 104.95 270 top
NOREF#4569  -  []  44.08 34.47 270 top
NOREF#4570  -  []  28.87 0.16 0 top
NOREF#4571  -  []  121.08 33.01 90 top
NOREF#4572  -  []  76.89 98.6 270 top
NOREF#4573  -  []  41.72 25.63 0 top
NOREF#4574  -  []  12.14 80.21 90 top
NOREF#4575  -  []  122.25 170.13 0 top
NOREF#4576  -  []  79.32 26.23 270 top
NOREF#4577  -  []  115.43 34.47 0 top
NOREF#4578  -  []  57.91 95.71 0 top
NOREF#4579  -  []  65.75 91.07 90 top
NOREF#4580  -  []  62.1 62.1 270 top
NOREF#4581  -  []  134.06 146.89 90 top
NOREF#4582  -  []  61.75 181.84 90 top
NOREF#4583  -  []  127.52 64.9 0 top
NOREF#4584  -  []  133.34 165.36 90 top
NOREF#4585  -  []  113.87 157.78 0 top
NOREF#4586  -  []  91.77 60.91 270 top
NOREF#4587  -  []  37.36 105.44 0 top
NOREF#4588  -  []  116.2 74.32 90 top
NOREF#4589  -  []  100.97 17.44 90 top
NOREF#4590  -  []  89.78 36.63 0 top
NOREF#4591  -  []  156.67 100.53 90 top
NOREF#4592  -  []  57.59 113.07 270 top
NOREF#4593  -  []  53.2 36.63 0 top
NOREF#4594  -  []  57.35 76 270 top
NOREF#4595  -  []  36.7 39.52 90 top
NOREF#4596  -  []  61.47 51.84 90 top
NOREF#4597  -  []  55.63 57.28 90 top
NOREF#4598  -  []  43.41 81.33 0 top
NOREF#4599  -  []  73.1 80.06 0 top
NOREF#4600  -  []  63.82 101.51 0 top
NOREF#4601  -  []  56.26 36.84 270 top
NOREF#4602  -  []  65.23 33.6 270 top
NOREF#4603  -  []  121.11 171.75 270 top
NOREF#4604  -  []  138.56 17.4 90 top
NOREF#4605  -  []  112.45 128.45 270 top
NOREF#4606  -  []  146.79 107.77 0 top
NOREF#4607  -  []  64.31 26.99 270 top
NOREF#4608  -  []  60.48 60.96 0 top
NOREF#4609  -  []  66.62 51.79 90 top
NOREF#4610  -  []  123.7 171.41 270 top
NOREF#4611  -  []  69.98 33.52 90 top
NOREF#4612  -  []  49.35 108.38 0 top
NOREF#4613  -  []  19.8 29.46 0 top
NOREF#4614  -  []  141.25 148.16 0 top
NOREF#4615  -  []  133.03 88.39 0 top
NOREF#4616  -  []  60.48 65.15 0 top
NOREF#4617  -  []  95.86 109.91 0 top
NOREF#4618  -  []  137.77 42.09 0 top
NOREF#4619  -  []  144.81 100.05 270 top
NOREF#4620  -  []  96.76 91.64 90 top
NOREF#4621  -  []  60.78 84.25 270 top
NOREF#4622  -  []  83.11 58.42 270 top
NOREF#4623  -  []  137.24 102.95 0 top
NOREF#4624  -  []  130.56 42.28 90 top
NOREF#4625  -  []  135.56 131.32 270 top
NOREF#4626  -  []  134.95 104.95 0 top
NOREF#4627  -  []  148.08 193.8 90 top
NOREF#4628  -  []  3.53 85.29 0 top
NOREF#4629  -  []  73.79 25.79 270 top
NOREF#4630  -  []  30.59 36.58 0 top
NOREF#4631  -  []  60.57 34.52 0 top
NOREF#4632  -  []  157.12 25.53 0 top
NOREF#4633  -  []  38.96 103.58 0 top
NOREF#4634  -  []  126.31 141.91 0 top
NOREF#4635  -  []  23.28 28.54 90 top
NOREF#4636  -  []  61.93 113.37 0 top
NOREF#4637  -  []  144.98 190.32 0 top
NOREF#4638  -  []  134.75 42.28 90 top
NOREF#4639  -  []  68.35 152.02 0 top
NOREF#4640  -  []  73.25 82.68 0 top
NOREF#4641  -  []  150.91 178.94 0 top
NOREF#4642  -  []  31.63 190.65 0 top
NOREF#4643  -  []  28.6 68.69 270 top
NOREF#4644  -  []  120.65 134.47 270 top
NOREF#4645  -  []  49.33 142.7 90 top
NOREF#4646  -  []  150.19 120.47 0 top
NOREF#4647  -  []  73.14 26.54 0 top
NOREF#4648  -  []  126.44 155.02 0 top
NOREF#4649  -  []  57.33 151.18 270 top
NOREF#4650  -  []  17.98 30.98 90 top
NOREF#4651  -  []  45.67 138.13 0 top
NOREF#4652  -  []  77.53 25.65 0 top
NOREF#4653  -  []  97.61 25.69 90 top
NOREF#4654  -  []  104.72 139.88 0 top
NOREF#4655  -  []  45.73 34.52 270 top
NOREF#4656  -  []  118.24 152.91 90 top
NOREF#4657  -  []  128.79 64.9 0 top
NOREF#4658  -  []  139.6 107.24 90 top
NOREF#4659  -  []  125.65 133.43 90 top
NOREF#4660  -  []  89.32 31.65 0 top
NOREF#4661  -  []  74.42 89.59 0 top
NOREF#4662  -  []  124.12 46.18 0 top
NOREF#4663  -  []  67.89 151.18 270 top
NOREF#4664  -  []  51.46 150.75 0 top
NOREF#4665  -  []  85.88 191.26 0 top
NOREF#4666  -  []  25.36 36.83 90 top
NOREF#4667  -  []  129.04 143.54 270 top
NOREF#4668  -  []  96.72 138 0 top
NOREF#4669  -  []  101.02 139.88 270 top
NOREF#4670  -  []  126.57 52.46 0 top
NOREF#4671  -  []  35.89 37.39 0 top
NOREF#4672  -  []  116.93 37.95 0 top
NOREF#4673  -  []  134.26 147.47 90 top
NOREF#4674  -  []  89.28 32.14 90 top
NOREF#4675  -  []  156.54 178.36 0 top
NOREF#4676  -  []  102.16 139.88 270 top
NOREF#4677  -  []  119.18 26.99 270 top
NOREF#4678  -  []  130.12 69.42 90 top
NOREF#4679  -  []  51.94 50.06 90 top
NOREF#4680  -  []  106.79 140 0 top
NOREF#4681  -  []  131.04 87.96 0 top
NOREF#4682  -  []  57.26 23.8 0 top
NOREF#4683  -  []  37.07 25.22 90 top
NOREF#4684  -  []  41.1 25.67 90 top
NOREF#4685  -  []  157.09 184.78 0 top
NOREF#4686  -  []  110.36 23.76 270 top
NOREF#4687  -  []  152.93 87.92 90 top
NOREF#4688  -  []  149.17 71.17 0 top
NOREF#4689  -  []  122.38 159.56 270 top
NOREF#4690  -  []  30.94 32.35 90 top
NOREF#4691  -  []  84.86 94.11 270 top
NOREF#4692  -  []  18.15 36.57 90 top
NOREF#4693  -  []  131.84 44.63 270 top
NOREF#4694  -  []  107.94 29.84 0 top
NOREF#4695  -  []  47.36 32.51 0 top
NOREF#4696  -  []  72.57 81.66 0 top
NOREF#4697  -  []  19.63 108.79 90 top
NOREF#4698  -  []  17.98 30.98 0 top
NOREF#4699  -  []  54.81 30.75 0 top
NOREF#4700  -  []  76.4 37.17 270 top
NOREF#4701  -  []  63.4 188.59 0 top
NOREF#4702  -  []  140.03 133.78 0 top
NOREF#4703  -  []  28.52 38.43 0 top
NOREF#4704  -  []  121.79 133.5 90 top
NOREF#4705  -  []  38.76 87.35 0 top
NOREF#4706  -  []  135.38 17.44 90 top
NOREF#4707  -  []  121.41 171.41 270 top
NOREF#4708  -  []  62.11 109.56 90 top
NOREF#4709  -  []  85.2 26.92 0 top
NOREF#4710  -  []  46.35 145.16 0 top
NOREF#4711  -  []  55.36 23.8 0 top
NOREF#4712  -  []  26.92 38.85 90 top
NOREF#4713  -  []  36.6 86.49 0 top
NOREF#4714  -  []  41 99.92 0 top
NOREF#4715  -  []  83.9 33.29 0 top
NOREF#4716  -  []  152.04 148.08 0 top
NOREF#4717  -  []  64.31 27.75 270 top
NOREF#4718  -  []  116.98 36.02 90 top
NOREF#4719  -  []  150.6 17.02 270 top
NOREF#4720  -  []  95.24 91.39 0 top
NOREF#4721  -  []  69.77 151.59 90 top
NOREF#4722  -  []  107.43 36.63 270 top
NOREF#4723  -  []  138.42 177.32 0 top
NOREF#4724  -  []  139.78 43.51 90 top
NOREF#4725  -  []  119.53 88.14 0 top
NOREF#4726  -  []  10.16 80.67 90 top
NOREF#4727  -  []  65.48 177.34 0 top
NOREF#4728  -  []  6.79 161.46 90 top
NOREF#4729  -  []  92.93 99.68 90 top
NOREF#4730  -  []  147.14 134.54 0 top
NOREF#4731  -  []  17.98 34.4 0 top
NOREF#4732  -  []  49.78 150.5 90 top
NOREF#4733  -  []  124.28 65.23 0 top
NOREF#4734  -  []  129.17 54.81 90 top
NOREF#4735  -  []  46.34 73.3 0 top
NOREF#4736  -  []  74.42 83.49 0 top
NOREF#4737  -  []  61.19 70.31 0 top
NOREF#4738  -  []  24.17 28.55 0 top
NOREF#4739  -  []  98.27 101.14 270 top
NOREF#4740  -  []  52.74 32.28 0 top
NOREF#4741  -  []  112.73 36.2 90 top
NOREF#4742  -  []  151.21 91.9 0 top
NOREF#4743  -  []  157.66 184.65 90 top
NOREF#4744  -  []  24.93 28.55 90 top
NOREF#4745  -  []  102.44 138 0 top
NOREF#4746  -  []  94.59 102.95 0 top
NOREF#4747  -  []  57.28 109.59 90 top
NOREF#4748  -  []  83.93 29.72 0 top
NOREF#4749  -  []  56.9 150.72 270 top
NOREF#4750  -  []  22.93 21.79 90 top
NOREF#4751  -  []  86.16 110.67 270 top
NOREF#4752  -  []  83.82 58.08 270 top
NOREF#4753  -  []  125.34 38.48 0 top
NOREF#4754  -  []  135.36 89.97 0 top
NOREF#4755  -  []  73.1 78.05 0 top
NOREF#4756  -  []  116.07 36.63 270 top
NOREF#4757  -  []  126.44 153.75 0 top
NOREF#4758  -  []  78.85 34.47 0 top
NOREF#4759  -  []  83.9 31.93 0 top
NOREF#4760  -  []  61.34 83.95 270 top
NOREF#4761  -  []  127.97 54.72 90 top
NOREF#4762  -  []  122.89 182.04 0 top
NOREF#4763  -  []  92.06 36.27 0 top
NOREF#4764  -  []  134.06 148.77 0 top
NOREF#4765  -  []  138.89 106.93 90 top
NOREF#4766  -  []  18.87 20.82 90 top
NOREF#4767  -  []  27.93 28.56 90 top
NOREF#4768  -  []  72.29 83.92 270 top
NOREF#4769  -  []  46.05 145.72 0 top
NOREF#4770  -  []  150.88 176.4 90 top
NOREF#4771  -  []  53.05 199.26 0 top
NOREF#4772  -  []  55.37 58.25 270 top
NOREF#4773  -  []  83.71 53.94 90 top
NOREF#4774  -  []  126.26 88.01 0 top
NOREF#4775  -  []  38.96 102.44 0 top
NOREF#4776  -  []  133.05 122.1 0 top
NOREF#4777  -  []  136.83 24.92 90 top
NOREF#4778  -  []  83.95 25.78 0 top
NOREF#4779  -  []  145.97 120.47 0 top
NOREF#4780  -  []  140.16 139.47 0 top
NOREF#4781  -  []  62.36 83.95 270 top
NOREF#4782  -  []  108.03 60.04 90 top
NOREF#4783  -  []  53.24 167.13 0 top
NOREF#4784  -  []  37.71 23.8 270 top
