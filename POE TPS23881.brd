# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 101.2
  BOTTOM w0.305: v3(58.36,105.82) U67.H2 58.88,105.54 59.44,105.54 U67.J2
  BOTTOM w0.356: U67.K17 v3(59.96,93.02) ; U67.T17 65.16,93.42 v3(65.56,93.02) ; U67.R17 64.36,93.42 v3(64.76,93.02) ; U67.N17 v3(62.36,93.02) ; U67.T15 65.16,95.02 v3(65.56,94.62) ; v3(61.56,100.22) 61.96,99.82 U67.M9 ; v3(63.96,93.02) 63.56,93.42 U67.P17 ; U67.T9 v3(65.56,100.22) ; U67.K9 v3(59.96,100.22) ; U67.P9 v3(63.96,100.22) ; U67.N9 v3(62.36,100.22) ; U67.K13 v3(59.96,97.02) ; U67.K14 v3(59.96,95.42) ; U67.T13 v3(65.56,97.02) ; U67.L17 v3(60.76,93.02) ; U67.T12 v3(65.56,97.82) ; U67.L9 v3(60.76,100.22) ; U67.M17 v3(61.56,93.02) ; U67.K12 v3(59.96,97.82) ; U67.R9 v3(64.76,100.22)
  BOTTOM w0.381: U67.AF10 v3(73.56,99.42) ; U67.T2 v3(65.56,105.82) ; U67.AF4 v3(73.56,104.22) ; U67.D16 55.56,94.22 v3(55.16,93.82) ; U67.AD7 v3(71.96,101.82) ; U67.AC6 v3(71.16,102.62) U67.AD5 ; U67.D23 55.56,88.62 v3(55.16,88.22) ; U67.V1 v3(67.16,106.62) ; U67.AE2 v3(72.76,105.82) ; U67.AE16 72.36,94.22 v3(72.76,93.82) ; v3(73.56,89.02) 73.16,89.42 U67.AF22 ; U67.AC8 v3(71.16,101.02) ; U67.K26 v3(59.95,86.62) ; U67.C13 v3(54.36,97.02) ; U67.A13 v3(52.76,97.02) ; U67.AD1 v3(71.96,106.62) ; U67.J24 59.56,87.82 v3(59.16,87.42) ; U67.R1 v3(64.76,106.62) ; U67.V26 66.36,85.82 U67.U26 U67.T25 65.16,87.01 v3(64.76,86.62) 64.36,87.02 U67.R25 v3(63.96,87.42) 63.56,87.82 U67.P24 ; v3(55.96,93.02) 56.36,93.42 U67.E17 ; v3(72.76,90.62) 72.36,91.02 U67.AE20 ; U67.A18 v3(52.76,92.22) ; U67.AC20 v3(71.16,90.62) ; U67.N4 v3(62.36,104.22) ; v3(54.36,88.22) 54.76,88.62 U67.C23 ; v3(59.16,85.82) 59.56,86.22 U67.J26 ; U67.B3 v3(53.56,105.02) ; v3(71.16,93.82) 70.76,94.22 U67.AC16 ; U67.AF18 73.16,92.62 v3(73.56,92.22) ; U67.P26 63.56,86.22 v3(63.16,85.82) U67.N26 ; U67.P1 v3(63.96,106.62) ; U67.E24 56.36,87.82 v3(56.76,87.42) 57.16,87.82 U67.F24 ; U67.B21 53.96,90.22 v3(53.56,89.82) ; U67.AC19 70.76,91.82 v3(71.16,91.42) ; U67.AE23 v3(72.76,88.22) ; U67.F1 v3(57.56,106.62) U67.G1 ; U67.C14 v3(54.36,95.42) ; U67.C18 54.76,92.62 v3(54.36,92.22) ; U67.C5 v3(54.36,103.42) ; U67.C10 v3(54.36,99.42) ; U67.E4 v3(55.96,104.22) ; U67.W25 v3(67.96,86.62) 68.36,87.02 U67.Y25 ; U67.D22 55.56,89.42 v3(55.16,89.02) ; U67.Y4 v3(68.76,104.22) U67.AA4 v3(69.56,104.22) ; U67.P3 v3(63.96,105.02) ; U67.D12 v3(55.16,97.82) ; U67.AF26 v3(73.56,85.82) ; v3(55.16,90.62) 55.56,91.02 U67.D20 ; U67.AD11 v3(71.96,98.62) ; U67.AE19 72.36,91.82 v3(72.76,91.42) ; v3(68.76,85.82) 69.16,86.21 U67.AA26 ; v3(72.76,94.62) 72.36,95.02 U67.AE15 ; U67.AB21 v3(70.36,89.82) ; U67.A4 v3(52.76,104.22) ; U67.A17 v3(52.76,93.02) ; U67.H4 v3(58.36,104.22) ; U67.AC10 v3(71.16,99.42) ; U67.U4 v3(66.36,104.22) ; U67.N2 v3(62.36,105.82) U67.M2 ; U67.D11 v3(55.16,98.62) ; U67.K3 v3(60.76,105.02) U67.L3 ; U67.U24 65.96,87.82 v3(65.56,88.22) U67.T23 ; U67.AB17 69.96,93.42 v3(70.36,93.02) ; U67.AB1 v3(69.96,106.76) ; U67.A20 53.16,91.02 v3(52.76,90.62) ; U67.AF17 73.16,93.42 v3(73.56,93.02) ; U67.G23 57.96,88.62 v3(57.56,88.22) ; U67.T4 v3(65.56,104.22) ; U67.B11 53.96,98.22 v3(53.56,98.62) ; v3(73.56,89.82) 73.16,90.22 U67.AF21 ; v3(60.76,88.22) 61.16,88.62 U67.L23 ; U67.E18 56.36,92.62 v3(55.96,92.22) ; U67.AD18 71.56,92.62 v3(71.96,92.22) ; U67.AA2 v3(68.76,105.82) ; U67.E13 v3(55.96,97.02) ; U67.A14 v3(52.76,95.42) ; U67.AD17 71.56,93.42 v3(71.96,93.02) ; U67.AF6 v3(73.56,102.62) ; U67.G25 v3(58.36,86.62) U67.H25 ; U67.B16 v3(53.56,93.82) ; U67.M4 v3(61.56,104.22) ; U67.AA5 v3(68.76,102.62) ; U67.V24 v3(67.16,87.42) ; U67.H23 58.76,88.62 v3(58.36,88.22) ; U67.Y2 v3(67.96,105.82) ; U67.AC4 v3(71.16,104.22) ; U67.A10 v3(52.76,99.42) ; v3(53.56,97.82) 53.96,97.42 U67.B12 ; U67.A24 53.16,87.82 v3(52.76,87.42) ; U67.E2 v3(55.96,105.82) ; U67.AD21 v3(71.96,89.82) ; U67.E14 56.36,95.82 v3(55.96,95.42) ; U67.K24 60.36,87.82 v3(59.96,87.42) ; v3(71.16,94.62) 70.76,95.02 U67.AC15 ; U67.B15 v3(53.56,94.62) ; U67.AD9 v3(71.96,100.22) ; U67.G3 v3(57.56,105.02) U67.F3 ; v3(61.56,88.22) 61.96,88.62 U67.M23 U67.N24 ; U67.AA7 v3(69.56,101.82) ; U67.AF8 72.79,100.99 v3(72.77,100.99) ; U67.W3 v3(67.96,105.02) ; U67.AB3 v3(70.36,105.02) ; U67.C17 54.76,93.42 v3(54.36,93.02) ; U67.R23 v3(64.76,88.22) ; U67.L1 v3(60.76,106.62) U67.K1 ; U67.Y23 v3(68.76,88.22) ; U67.M25 61.96,87.02 v3(61.56,86.62) 61.16,87.02 U67.L25 ; U67.AB18 v3(70.36,92.22) ; U67.AD22 v3(71.96,89.02) ; U67.AE24 v3(72.76,87.42) ; U67.A26 53.16,86.22 v3(52.76,85.82) ; U67.AA24 v3(69.56,87.42) ; U67.W1 v3(67.96,106.62) ; U67.J4 v3(59.16,104.22) ; U67.AD2 v3(71.96,105.82) ; U67.AC26 v3(71.16,85.82) ; U67.AE1 v3(72.76,106.62) ; U67.B2 v3(53.56,105.82) ; v3(53.56,86.62) 53.96,87.02 U67.B25 ; U67.AB8 v3(70.36,101.02) ; U67.AC25 v3(71.16,86.62) ; U67.D15 v3(55.16,94.62) ; U67.V3 v3(67.16,105.02) ; U67.F26 57.16,86.22 v3(56.76,85.82) 56.36,86.22 U67.E26 ; U67.D25 55.56,87.02 v3(55.16,86.62) ; U67.C1 v3(54.36,106.62) ; U67.W23 v3(67.96,88.22) ; U67.AB10 v3(70.36,99.42) ; U67.R3 v3(64.76,105.02) ; U67.U2 v3(66.36,105.82) ; U67.AC23 v3(71.16,88.22) ; U67.AB22 v3(70.36,89.02)
V0P9_LAN1: length 5.1
  TOP w0.305: CB49.1 19.23,34.29 v1(19.18,34.24) ; v1(29.95,32.14) 29.93,32.13 CB66.1
  BOTTOM w0.229: U41.32 28.31,37.9 28.52,38.1 v1(28.83,38.1) ; U41.42 v1(29.95,32.14) ; v1(19.18,34.24) 19.27,34.14 U41.11 ; U41.59 23.31,27.76 v1(23.01,27.46)
  vias: v1(29.46,38.1)
V0P9_LAN2: length 5
  TOP w0.305: v1(46.71,29.22) 46.7,29.21 CB82.1 ; CB68.1 35.99,31.37 v1(35.94,31.32)
  BOTTOM w0.229: v1(45.59,35.18) 45.28,35.18 45.08,34.98 U43.32 ; U43.42 v1(46.71,29.22) ; U43.11 36.04,31.22 v1(35.94,31.32) ; U43.59 v1(40.08,24.59)
  vias: v1(46.23,35.18)
V0P9_LAN3: length 5
  TOP w0.305: CB83.1 64.99,29.21 v1(65,29.22) ; CB69.1 54.28,31.37 v1(54.23,31.32)
  BOTTOM w0.229: U45.11 54.33,31.22 v1(54.23,31.32) ; U45.42 v1(65,29.22) ; U45.59 v1(58.36,24.59) ; U45.32 63.36,34.98 63.57,35.18 v1(63.88,35.18)
  vias: v1(64.52,35.18)
V0P9_LAN4: length 5
  TOP w0.305: CB84.1 83.27,29.21 v1(83.29,29.22) ; CB70.1 72.57,31.37 v1(72.52,31.32)
  BOTTOM w0.229: U47.59 v1(76.65,24.59) ; v1(72.52,31.32) 72.61,31.22 U47.11 ; v1(82.17,35.18) 81.86,35.18 81.65,34.98 U47.32
  BOTTOM w0.254: U47.42 v1(83.29,29.22)
  vias: v1(82.93,35.18)
V0P9_LAN5: length 5
  TOP w0.305: CB71.1 90.86,31.37 v1(90.81,31.32) ; v1(101.57,29.22) 101.56,29.21 CB85.1
  BOTTOM w0.229: U49.11 90.9,31.22 v1(90.81,31.32) ; U49.59 v1(94.94,24.59) ; v1(100.46,35.18) 100.14,35.18 99.94,34.98 U49.32
  BOTTOM w0.254: U49.42 v1(101.57,29.22)
  vias: v1(101.09,35.18)
V0P9_LAN6: length 5
  TOP w0.305: v1(109.09,31.32) 109.14,31.37 CB72.1 ; v1(119.86,29.22) 119.85,29.21 CB86.1
  BOTTOM w0.229: U51.11 109.19,31.22 v1(109.09,31.32) ; U51.32 118.23,34.98 118.43,35.18 v1(118.75,35.18) ; U51.42 v1(119.86,29.22) ; U51.59 v1(113.23,24.59)
  vias: v1(119.33,35.18)
V0P9_LAN7: length 5
  TOP w0.305: v1(127.38,31.7) 127.43,31.75 CB67.1 ; CB81.1 138.14,29.59 v1(138.15,29.6)
  BOTTOM w0.229: v1(127.38,31.7) 127.48,31.6 U53.11 ; U53.32 136.52,35.36 136.72,35.56 v1(137.03,35.56) ; U53.42 v1(138.15,29.6) ; U53.59 v1(131.52,24.97)
  vias: v1(137.67,35.56)
V0P9_LAN8: length 5
  TOP w0.305: v1(131.81,54.2) 131.83,54.19 CB32.1 ; v1(129.72,43.43) 129.67,43.48 CB42.1
  BOTTOM w0.229: U55.32 126.06,52.57 125.86,52.77 v1(125.86,53.09) ; U55.59 v1(136.45,47.57) ; v1(129.72,43.43) 129.81,43.53 U55.11 ; U55.42 v1(131.81,54.2)
  vias: v1(125.86,53.72)
V1P5_LAN1: length 10
  IN3 w0.508: v1(24.81,27.51) 26.13,26.19 27.94,26.19 28.73,26.97 28.73,28.93 29.38,29.58 v1(29.97,29.58)
  BOTTOM w0.203: U41.56 v1(24.81,27.51)
  BOTTOM w0.229: U41.47 29.91,29.64 v1(29.97,29.58)
V1P5_LAN2: length 9.9
  IN3 w0.508: v1(41.58,24.59) 42.79,23.37 45.19,23.37 45.69,23.88 45.69,25.88 46.47,26.66 v1(46.74,26.66)
  BOTTOM w0.229: U43.56 v1(41.58,24.59) ; U43.47 46.67,26.72 v1(46.74,26.66)
V1P5_LAN3: length 9.9
  IN3 w0.508: v1(59.86,24.59) 61.08,23.37 63.5,23.37 64.01,23.88 64.01,25.91 64.76,26.66 v1(65.02,26.66)
  BOTTOM w0.229: U45.56 v1(59.86,24.59) ; U45.47 64.96,26.72 v1(65.02,26.66)
V1P5_LAN4: length 10
  IN3 w0.508: v1(83.31,26.66) 83.05,26.66 82.32,25.93 82.32,24 81.56,23.24 79.5,23.24 v1(78.15,24.59)
  BOTTOM w0.229: U47.56 v1(78.15,24.59)
  BOTTOM w0.254: U47.47 83.25,26.72 v1(83.31,26.66)
V1P5_LAN5: length 9.9
  IN3 w0.508: v1(101.6,26.66) 101.33,26.66 100.48,25.81 100.48,23.88 99.97,23.37 97.66,23.37 v1(96.44,24.59)
  BOTTOM w0.229: U49.56 v1(96.44,24.59)
  BOTTOM w0.254: v1(101.6,26.66) 101.54,26.72 U49.47
V1P5_LAN6: length 9.9
  IN3 w0.508: v1(119.89,26.66) 119.62,26.66 118.77,25.81 118.77,23.88 118.26,23.37 115.95,23.37 v1(114.73,24.59)
  BOTTOM w0.229: U51.56 v1(114.73,24.59) ; U51.47 119.82,26.72 v1(119.89,26.66)
V1P5_LAN7: length 10.1
  IN3 w0.508: v1(138.18,27.04) 137.74,27.04 137.06,26.35 137.06,24.18 136.55,23.67 134.92,23.67 133.63,24.97 v1(133.02,24.97)
  BOTTOM w0.229: v1(138.18,27.04) 138.11,27.1 U53.47 ; U53.56 v1(133.02,24.97)
V1P5_LAN8: length 7.7
  IN3 w0.508: v1(134.38,54.23) 134.38,53.86 135.53,52.7 135.53,50.08 v1(136.45,49.17)
  BOTTOM w0.229: v1(136.45,49.17) 136.35,49.07 U55.56 ; U55.47 134.31,54.17 v1(134.38,54.23)
V1P8_B: length 26.1
  IN3 w0.508: v1(144.65,180.72) 145.67,180.72 148.72,183.77 148.72,189.1 150.83,191.21 v1(157.84,191.21)
  BOTTOM w0.508: R212.2 R216.2 v1(144.65,180.72) ; R222.1 v1(157.84,191.21)
V3.3_M2_B: length 11.9
  BOTTOM w0.254: U32.6 142.39,177.16 R226.2
  BOTTOM w0.305: v1(149.86,176.5) 149.78,176.42 NGFF1.4 147.52,176.42 v1(147.45,176.5) ; v1(149.86,175.87) 149.81,175.92 NGFF1.2 147.5,175.92 v1(147.45,175.87) ; NGFF1.72 v1(149.86,193.42) ; NGFF1.70 v1(147.45,192.92) ; RA51.1 v1(140.92,179.96) ; NGFF1.74 v1(147.45,193.92)
  BOTTOM w0.508: R221.2 v1(144.65,188.59) ; v1(146.94,178.79) R213.2
  vias: v1(142.19,176.38) v1(142.8,176.38) v1(151,187.2) v1(152.02,187.2) v1(153.03,187.2)
V3P3_LAN1: length 25.7
  TOP w0.305: R290.1 RA23.2 18.15,35.28 v1(18.15,35.81)
  BOTTOM w0.203: 20.81,27.92 20.81,27.8 v1(20.52,27.51)
  BOTTOM w0.229: 30.23,32.64 U41.41 ; v1(25.65,38.28) 25.81,38.12 U41.27 ; U41.51 v1(27.31,27.51) ; RA131.2 RA130.2 RA129.2 v1(21.79,25.43) ; RA131.2 v1(20.52,25.43) ; RA131.2 RA132.2 ; U41.10 v1(19.18,33.64) ; 20.81,27.92 U41.64
  BOTTOM w0.254: v1(18.15,35.81) 17.91,36.06 CB141.1
  BOTTOM w0.305: RA89.1 31.13,32.02 30.98,32.17 CB148.1 30.61,32.49 30.45,32.64 30.23,32.64 ; RA89.1 v1(31.75,31.75) ; RA89.1 RA91.1 ; v1(20.57,40.51) R277.2 R278.2 ; RA66.1 RA67.1 RA68.1 v1(31.75,35.31) ; v1(26.92,39.93) R279.2 R269.1 ; R275.1 v1(18.02,29.97) R276.2 RA92.1 RA90.1 v1(18.02,32.26) RA83.1 RA76.1
  BOTTOM w0.508: R274.2 v1(19.56,40.51) ; LANLINK1.A1 33.05,39.97 32.78,40.25 LANACT1.A ; LANLINK1.A1 LANLINK1.A2 ; LANLINK1.A1 v1(34.04,39.26)
V3P3_LAN2: length 23.2
  TOP w0.229: CB129.1 v1(37.21,24.64)
  TOP w0.254: U44.8 v1(34.91,32.89)
  TOP w0.305: v1(34.91,32.89) 34.91,32.36 RA25.2 R314.1
  BOTTOM w0.229: RA156.2 RA155.2 ; RA155.2 RA154.2 RA153.2 v1(39.12,22.68) ; RA155.2 v1(37.85,22.68) ; U43.51 v1(44.08,24.51) ; U43.41 46.99,29.72 ; U43.64 37.58,25 v1(37.21,24.64) ; U43.10 v1(35.94,30.72) ; v1(42.42,35.36) 42.58,35.2 U43.27
  BOTTOM w0.254: v1(34.91,32.89) 34.67,33.14 CB147.1
  BOTTOM w0.305: R299.1 v1(34.79,27.05) R300.2 RA128.1 RA116.1 v1(34.79,29.34) RA104.1 RA98.1 ; RA115.1 47.89,29.01 47.61,29.29 47.61,29.29 47.36,29.54 CB154.1 47.35,29.72 46.99,29.72 ; RA115.1 v1(48.51,28.83) ; RA115.1 RA127.1 ; v1(43.05,37.21) R293.1 R303.2 ; RA74.1 RA81.1 RA88.1 v1(48.51,32.51) ; R302.2 R301.2 v1(37.34,37.59)
  BOTTOM w0.508: R298.2 v1(36.32,37.59)
  vias: v1(45.35,39.12) v1(49.15,39.12)
V3P3_LAN3: length 22.4
  TOP w0.229: CB130.1 v1(55.5,24.64)
  TOP w0.305: v1(53.2,32.89) 53.2,32.36 RA26.2 R338.1
  BOTTOM w0.229: 65.28,29.72 U45.41 ; RA152.2 RA151.2 ; RA151.2 v1(56.13,22.68) ; RA151.2 RA150.2 RA149.2 v1(57.4,22.68) ; U45.27 60.86,35.2 v1(60.71,35.36) ; U45.64 55.86,25 v1(55.5,24.64) ; U45.10 v1(54.23,30.72) ; U45.51 v1(62.36,24.51)
  BOTTOM w0.254: CB146.1 52.96,33.14 v1(53.2,32.89)
  BOTTOM w0.305: 65.28,29.72 65.64,29.72 CB153.1 65.65,29.54 65.9,29.29 65.9,29.29 66.18,29.01 RA113.1 ; RA113.1 RA125.1 ; RA113.1 v1(66.8,28.83) ; R326.2 R325.2 v1(55.63,37.59) ; v1(61.34,37.21) R317.1 R327.2 ; v1(66.8,32.51) RA87.1 RA80.1 RA73.1 ; RA97.1 RA103.1 v1(53.07,29.34) RA114.1 RA126.1 R324.2 v1(53.07,27.05) R323.1
  BOTTOM w0.508: R322.2 v1(54.61,37.59)
  vias: v1(63.64,39.5) v1(65.26,39.5) v1(66.56,39.5)
V3P3_LAN4: length 23.2
  TOP w0.229: CB131.1 v1(73.79,24.64)
  TOP w0.305: v1(71.49,32.89) 71.49,32.36 RA27.2 R362.1
  BOTTOM w0.229: U47.27 79.15,35.2 v1(78.99,35.36) ; v1(72.52,30.72) U47.10 ; RA147.2 v1(74.42,22.68) ; RA147.2 RA148.2 ; RA147.2 RA146.2 RA145.2 v1(75.69,22.68) ; U47.51 v1(80.65,24.51) ; v1(73.79,24.64) 74.15,25 U47.64 ; U47.41 83.57,29.72
  BOTTOM w0.254: v1(71.49,32.89) 71.25,33.14 CB145.1
  BOTTOM w0.305: v1(73.91,37.59) R349.2 R350.2 ; RA111.1 84.47,29.02 84.23,29.26 84.1,29.26 83.93,29.43 CB152.1 83.93,29.72 83.57,29.72 ; RA111.1 RA123.1 ; RA111.1 v1(85.09,28.83) ; R351.2 R341.1 v1(79.63,37.59) ; R347.1 v1(71.06,26.75) 71.06,27.23 70.98,27.3 R348.2 RA124.1 RA112.1 v1(70.98,29.34) RA102.1 RA96.1 ; RA72.1 RA79.1 RA86.1 v1(85.09,32.51)
  BOTTOM w0.508: R346.2 v1(72.9,37.59)
  vias: v1(81.93,39.12) v1(85.7,39.07)
V3P3_LAN5: length 22.5
  TOP w0.229: CB132.1 v1(92.08,24.64)
  TOP w0.305: v1(89.78,32.89) 89.78,32.36 RA28.2 R386.1
  BOTTOM w0.229: U49.41 101.85,29.72 ; U49.10 v1(90.81,30.72) ; v1(93.98,22.68) RA141.2 RA142.2 RA143.2 ; RA143.2 v1(92.71,22.68) ; RA143.2 RA144.2 ; U49.27 97.44,35.2 v1(97.28,35.36) ; v1(92.08,24.64) 92.44,25 U49.64 ; U49.51 v1(98.94,24.51)
  BOTTOM w0.254: v1(89.78,32.89) 89.53,33.14 CB144.1
  BOTTOM w0.305: v1(97.92,37.21) R364.1 R375.2 ; RA109.1 102.76,29.12 102.59,29.29 102.47,29.29 102.22,29.54 CB151.1 102.22,29.72 101.85,29.72 ; RA109.1 RA121.1 ; RA109.1 v1(103.38,28.83) ; R371.1 v1(89.65,27.05) R372.2 RA122.1 RA110.1 v1(89.65,29.34) RA101.1 RA95.1 ; v1(103.38,32.51) RA85.1 RA78.1 RA71.1 ; v1(92.2,37.59) R373.2 R374.2
  BOTTOM w0.508: R370.2 v1(91.19,37.59)
  vias: v1(101.3,38.26) v1(104.42,38.26)
V3P3_LAN6: length 22.9
  TOP w0.229: CB133.1 v1(110.36,24.64)
  TOP w0.305: R410.1 RA29.2 108.07,32.36 v1(108.07,32.89)
  BOTTOM w0.229: 120.14,29.72 U51.41 ; U51.64 110.73,25 v1(110.36,24.64) ; RA140.2 RA139.2 ; RA139.2 RA138.2 RA137.2 v1(112.27,22.68) ; RA139.2 v1(111,22.68) ; U51.10 v1(109.09,30.72) ; U51.27 115.73,35.2 v1(115.57,35.36) ; U51.51 v1(117.23,24.51)
  BOTTOM w0.254: v1(108.07,32.89) 107.82,33.14 CB143.1
  BOTTOM w0.305: R398.2 R389.1 v1(116.2,37.59) ; v1(110.49,37.59) R397.2 R399.2 ; RA94.1 RA100.1 v1(107.94,29.34) RA108.1 RA120.1 R396.2 v1(107.94,27.05) R395.1 ; v1(121.67,28.83) RA107.1 ; RA107.1 RA119.1 ; RA107.1 121.04,29.07 120.83,29.29 120.76,29.29 120.51,29.54 CB150.1 120.51,29.72 120.14,29.72 ; v1(121.67,32.51) RA84.1 RA77.1 RA70.1
  BOTTOM w0.508: R394.2 v1(109.47,37.59)
  vias: v1(118.5,39.12) v1(120.13,39.5) v1(121.43,39.5)
V3P3_LAN7: length 25.4
  TOP w0.229: CB108.1 v1(128.65,25.02)
  TOP w0.305: v1(126.35,33.27) 126.35,32.74 RA24.2 R434.1
  BOTTOM w0.229: U53.64 129.02,25.38 v1(128.65,25.02) ; RA136.2 RA135.2 ; RA135.2 v1(129.29,23.06) ; RA135.2 RA134.2 RA133.2 v1(130.56,23.06) ; U53.51 v1(135.52,24.89) ; 138.43,30.1 U53.41 ; U53.10 v1(127.38,31.1) ; U53.27 134.02,35.58 v1(133.86,35.74)
  BOTTOM w0.254: CB142.1 126.11,33.52 v1(126.35,33.27)
  BOTTOM w0.305: v1(128.78,37.97) R421.2 R422.2 ; RA69.1 RA75.1 RA82.1 v1(139.95,32.89) ; v1(134.49,37.59) R412.1 R423.2 ; R419.1 v1(126.23,27.43) R420.2 RA118.1 RA106.1 v1(126.23,29.72) RA99.1 RA93.1 ; RA105.1 139.33,29.39 139.05,29.67 139.05,29.67 138.8,29.92 CB149.1 138.79,30.1 138.43,30.1 ; RA105.1 RA117.1 ; RA105.1 v1(139.95,29.21)
  BOTTOM w0.508: v1(136.53,39.5) 136.79,39.23 LANACT7.A ; R418.2 127.76,37.69 v1(128.04,37.97) ; LANLINK7.A2 v1(139.71,39.88) ; LANLINK7.A1 v1(138.42,39.88)
V3P3_LAN8: length 23.7
  TOP w0.229: CB40.1 v1(136.4,44.7)
  BOTTOM w0.229: U55.27 125.84,50.07 v1(125.68,49.91) ; U55.41 131.31,54.48 ; v1(136.4,44.7) 136.03,45.07 U55.64 ; U55.51 v1(136.45,51.57) ; U55.10 v1(130.31,43.43)
  BOTTOM w0.254: CB140.1 127.9,42.16 v1(128.14,42.41) ; RA61.2 RA60.2 v1(138.43,45.34) ; RA59.2 RA58.2 v1(138.43,46.61)
  BOTTOM w0.305: RA54.1 RA53.1 ; RA54.1 v1(132.21,56.01) ; RA54.1 131.88,55.38 131.78,55.28 131.78,54.99 131.64,54.85 CB139.1 131.31,54.85 131.31,54.48 ; R447.2 R445.2 v1(123.83,44.7) ; v1(128.78,55.88) 128.6,55.7 RA55.1 RA56.1 RA57.1 ; R446.2 R437.1 v1(123.83,50.55) ; RA65.1 RA64.1 v1(131.7,42.28) RA63.1 RA62.1 R444.2 v1(133.99,42.28) R443.1
  BOTTOM w0.381: LANACT8.A v1(125.48,60.68) ; LANLINK8.A2 v1(128.41,61.09) ; LANLINK8.A1 v1(127.11,61.09)
  BOTTOM w0.508: R442.2 v1(123.44,43.81)
VBUS_IN: length 4.5
  TOP w0.229: R163.1 75.25,70.93 RA7.1 76.59,70.36 76.59,69.83 77.47,68.95 U20.42
VCC1.8: length 2.1
  TOP w0.229: 77.4,157.04 U25.24
  TOP w0.254: C70.1 76.8,157.65 77.4,157.04
VCC5_USB2:
  vias: v1(78.79,49.83) v1(79.4,50.42) v1(79.4,49.83) v1(80.01,49.83)
VCC25P: length 49.7
  TOP w0.229: U70.54 v1(54.16,71.46) ; U70.13 v1(54.16,58.93) ; U70.48 v1(56.56,71.33) ; U70.85 v1(47.74,62.26) ; U70.19 v1(56.56,58.93) ; CM20.1 60.82,63.05 60.53,63.33 59.63,63.33 59.51,63.46 U70.29 ; U70.24 59.22,61.46 59.89,60.78 60.69,60.78 CM18.1 ; U70.68 47.94,69.06 47.76,69.23 47.76,69.93
  TOP w0.305: v3(61.56,101.02) 61.59,101.05 C349.1 ; v3(59.16,92.22) 59.13,92.19 C353.1 ; C333.1 60.02,92.16 v3(59.96,92.22) ; v3(59.16,93.02) 59.14,93.04 C346.1 ; C338.1 59.89,101.09 v3(59.96,101.02) ; v3(60.76,101.02) 60.78,101.04 C355.1 ; C336.1 65.61,92.17 v3(65.56,92.22) ; C357.1 56.26,98.12 v3(55.96,97.82) ; v3(66.36,92.22) 66.37,92.21 C343.1 ; v3(59.16,93.82) 59.15,93.8 C340.1 ; C359.1 62.31,92.16 v3(62.36,92.22) ; v3(64.76,101.02) 64.72,101.06 C351.1
  TOP w0.381: CM17.1 46.71,62.24 47.73,62.24 v1(47.74,62.26) ; CM19.1 54.15,72.04 54.15,71.47 v1(54.16,71.46) ; CM21.1 56.57,58.92 v1(56.56,58.93) ; CB9.2 v1(47.28,72.59) CM24.1 47.28,71.23 47.76,70.75 47.76,69.93 ; v1(60.15,62.81) CM20.1 ; v1(54.16,58.93) 54.16,58.44 CM23.1 ; v1(60.15,60.27) 60.44,60.27 CM18.1 ; v1(56.56,71.33) 56.55,71.34 56.55,72.03 CM22.1
  TOP w0.508: v1(59.87,71.42) 60.02,71.58 C377.1
  BOTTOM w0.356: U67.J17 v3(59.16,93.02) ; U67.K8 v3(59.96,101.02) ; U67.N18 v3(62.36,92.22) ; U67.T8 v3(65.56,101.02) ; U67.J18 v3(59.16,92.22) ; U67.M8 61.96,100.62 v3(61.56,101.02) ; U67.J16 v3(59.16,93.82) ; U67.U18 v3(66.36,92.22) ; U67.K18 v3(59.96,92.22) ; U67.L8 v3(60.76,101.02) ; v3(65.56,92.22) 65.16,92.62 U67.T18 ; U67.R8 v3(64.76,101.02) ; U67.U10 v3(66.36,99.42)
  BOTTOM w0.381: U67.AE13 72.36,96.62 v3(72.76,97.02) ; U67.AD14 71.56,95.82 v3(71.96,95.42) ; U67.AA16 69.16,94.22 v3(69.56,93.82) ; U67.AB14 69.96,95.82 v3(70.36,95.42) ; v3(71.16,97.82) 70.76,97.42 U67.AC12 ; v3(69.56,97.82) 69.16,97.42 U67.AA12 ; U67.AD13 71.56,96.62 v3(71.96,97.02) ; U67.AC14 70.76,95.82 v3(71.16,95.42) ; v3(71.96,97.82) 71.56,97.42 U67.AD12 ; U67.E12 v3(55.96,97.82) ; U67.AA13 69.16,96.62 v3(69.56,97.02) ; U67.AA15 69.16,95.02 v3(69.56,94.62) ; U67.AA14 69.16,95.82 v3(69.56,95.42) ; U67.E11 v3(55.96,98.62) ; U67.AF12 73.16,97.42 v3(73.56,97.82) ; U67.AF14 73.16,95.82 v3(73.56,95.42) ; U67.AE14 72.36,95.82 v3(72.76,95.42) ; U67.AF13 73.16,96.62 v3(73.56,97.02) ; U67.AB12 69.96,97.42 v3(70.36,97.82) ; U67.AC13 70.76,96.62 v3(71.16,97.02) ; v3(70.36,97.02) 69.96,96.62 U67.AB13 ; v3(72.76,97.82) 72.36,97.42 U67.AE12
  vias: v2(46.56,88.34) v2(47.32,89.87) v2(47.32,89.1) v2(47.32,88.34) v2(48.08,89.87) v2(48.08,89.1) v2(48.08,88.34) v2(48.84,89.87) v2(48.84,89.1) v2(48.84,88.34)
VCC_DCIN: length 73.3
  TOP w0.279: v1(9.98,108.28) 9.98,108.33 10.44,108.79 U83.3
  TOP w0.508: R720.1 v1(47.24,143.13) ; R663.1 38.05,166.7 37.41,166.07 ; v1(9.98,108.28) 9.98,107.8 R740.2 ; RB30.2 v1(17.53,106.58)
  IN1 w0.508: v1(9.98,108.28) 10.05,108.35 10.05,109.07 10.46,109.47 12.98,109.47 14.98,107.47 17.02,107.47 17.53,106.96 v1(17.53,106.58) ; 29.13,154.36 29.22,154.27 30.31,154.27 35.76,148.82 35.76,143.05 37.34,141.48 46.1,141.48 47.24,142.62 v1(47.24,143.13)
  BOTTOM w0.508: v1(9.98,108.28) 9.75,108.28 9.19,107.72 C922.2 8.46,107.8 C459.2 7.92,109.58 7.19,110.31 7.19,118.29 7.75,118.85 v2(7.75,119.63)
  vias: v2(6.1,127) v2(6.1,126.24) v2(6.1,120.4) v2(6.1,119.63) v2(6.86,127) v2(6.86,126.24) v2(6.99,120.4) v2(6.99,119.63) v2(7.62,127) v2(7.62,126.24) v2(7.75,120.4) v2(8.38,127) v2(8.38,126.24) v2(8.51,120.4) v2(8.51,119.63) v2(9.14,127) v2(9.14,126.24) v2(9.27,120.4) v2(9.27,119.63) v2(27.43,163.7) v2(27.43,160.66) v2(27.43,159.77) v2(28.32,163.7) v2(28.32,160.66) v2(28.32,159.77) v2(29.21,165.48) v2(29.21,164.59) v2(29.21,163.7) v2(29.21,160.66) v2(29.21,159.77) v2(29.21,158.88) v2(30.1,165.48) v2(30.1,164.59) v2(30.1,163.7) v2(30.1,160.66) v2(30.1,159.77) v2(30.1,158.88) v2(30.35,173.99) v2(30.35,173.1) v2(30.35,172.21) v2(30.35,169.04) v2(30.35,168.15) v2(30.35,167.26) v2(30.99,165.48) v2(30.99,164.59) v2(30.99,163.7) v2(30.99,160.66) v2(30.99,159.77) v2(30.99,158.88) v2(31.24,173.99) v2(31.24,173.1) v2(31.24,172.21) v2(31.24,169.04) v2(31.24,168.15) v2(31.24,167.26) v2(32.13,173.99) v2(32.13,173.1) v2(32.13,172.21) v2(32.13,169.04) v2(32.13,168.15) v2(32.13,167.26) v2(32.13,166.37) v2(33.02,173.99) v2(33.02,173.1) v2(33.02,172.21) v2(33.02,169.04) v2(33.02,168.15) v2(33.02,167.26) v2(33.02,166.37) v2(33.91,173.99) v2(33.91,173.1) v2(33.91,172.21) v2(33.91,169.04) v2(33.91,168.15) v2(33.91,167.26) v2(33.91,166.37) v2(34.8,173.99) v2(34.8,173.1) v2(35.69,173.99) v2(35.69,173.1)
VCC_SRC: length 110.7
  TOP w0.381: J1.G65 v1(110.1,127.52) ; J1.H3 v1(51.7,129.02) ; J1.C65 v1(110.1,121.52) ; J1.J64 v1(109.2,130.52) ; J1.F64 v1(109.4,126.02) ; J1.G2 v1(50.6,127.52) ; J1.B63 108.5,120.02 ; J1.D3 v1(51.7,123.02) ; J1.J63 v1(108.3,130.52) ; J1.H65 v1(110.3,129.02) ; J1.F3 v1(51.7,126.02) ; J1.G1 v1(49.7,127.52) ; J1.E1 v1(49.7,124.52) ; J1.C2 v1(50.6,121.52) ; J1.F1 v1(49.9,126.02) ; J1.J1 v1(49.7,130.52) ; J1.E63 v1(108.3,124.52) ; J1.J65 v1(110.1,130.52) ; J1.E64 v1(109.2,124.52) ; J1.G63 v1(108.3,127.52) ; J1.F2 v1(50.8,126.02) ; J1.D65 v1(110.3,123.02) ; J1.C63 v1(108.3,121.52) ; J1.K3 v1(51.7,131.97) ; J1.H2 v1(50.8,129.02) ; J1.F65 v1(110.3,126.02) ; J1.F63 v1(108.5,126.02) ; J1.C64 v1(109.2,121.52) ; J1.D64 v1(109.4,123.02) ; J1.C1 v1(49.7,121.52) ; J1.H64 v1(109.4,129.02) ; J1.G64 v1(109.2,127.52) ; J1.D2 v1(50.8,123.02) ; J1.E2 v1(50.6,124.52) ; J1.H1 v1(49.9,129.02) ; J1.J2 v1(50.6,130.52) ; J1.E65 v1(110.1,124.52) ; J1.D1 v1(49.9,123.02) ; J1.B3 v1(51.7,120.02)
  IN1 w1.27: 5.23,110.87 3.07,110.87 1.98,111.96 1.98,165.43 5.64,169.09 5.64,173.2 5.13,173.71 5.13,182.22 5.66,182.75
  IN2 w0.508: 76.95,176.07 U27.2 ; U27.2 77.93,175.09 ; U27.2 77.93,177.04 ; U27.2 78.91,176.07 ; 51.64,175.17 U39.2 ; U39.2 50.66,176.15 ; U39.2 52.62,176.15 ; U39.2 51.64,177.13
  BOTTOM w0.508: R139.2 v1(2.41,189.23)
  vias: v1(6.2,111.53) v1(6.2,110.87) v1(45.21,130.18) v1(45.21,129.54) v1(45.21,127.25) v1(45.21,126.62) v1(45.85,130.18) v1(45.85,129.54) v1(45.85,127.25) v1(45.85,126.62) v1(46.48,130.18) v1(46.48,129.54) v1(46.48,127.25) v1(46.48,126.62) v1(56.64,175.64) v1(56.64,175.01) v1(57.43,175.01) v1(58.32,175.01) v1(59.18,175.64) v1(59.18,175.01) v1(59.18,151.64) v1(59.18,151) v1(59.18,150.37) v1(59.82,151.64) v1(59.82,151) v1(59.82,150.37) v1(60.45,151.64) v1(60.45,151) v1(60.45,150.37) v1(61.09,151.64) v1(61.09,151) v1(61.09,150.37) v1(61.72,151.64) v1(61.72,151) v1(61.72,150.37) v1(62.36,151.64) v1(62.36,151) v1(62.36,150.37) v1(70.48,173.86) v1(71.12,173.86) v1(72.9,173.86) v1(110.74,121.54) v1(114.43,130.43) v1(114.43,129.79) v1(114.43,129.16) v1(115.06,130.43) v1(115.06,129.79) v1(115.06,129.16)
VDD105: length 12.8
  TOP w0.229: U70.9 52.56,59.54 v1(51.89,58.88) ; U70.58 52.56,70.99 52.32,71.22 v1(52.32,71.45) ; CM5.1 60.69,64.72 59.77,64.72 59.43,65.06 U70.33 ; U70.23 58.98,61.06 59.51,60.53 59.51,60.15 60.02,59.64 CM8.1
  TOP w0.381: CM5.1 60.44,65.23 v1(60.15,65.23) ; CM14.1 51.94,71.83 v1(52.32,71.45) ; CM11.1 v1(51.89,58.88)
  TOP w0.508: CM8.1 v1(60.82,59) ; v1(44.04,60.55) 43.92,60.43 FB36.2
VDD105P: length 53.8
  TOP w0.229: U70.22 v1(57.76,58.93) ; U70.73 v1(47.74,67.06) ; U70.45 v1(57.76,71.33) ; U70.26 60.59,62.26 60.82,62.03 CM6.1 ; U70.51 v1(55.36,71.46) ; U70.88 47.89,61.06 v1(47.74,60.9) ; U70.16 v1(55.36,58.93) ; v1(52.95,58.93) 52.95,60.29 U70.10 ; CM2.1 60.82,64.11 60.59,64.34 59.51,64.34 59.19,64.66 U70.32 ; U70.82 v1(47.74,63.46)
  TOP w0.254: U70.57 v1(52.96,71.45)
  TOP w0.305: C342.1 66.37,97.03 v3(66.36,97.02) ; C356.1 62.56,101.22 v3(62.36,101.02) ; v3(60.76,92.22) v3(61.56,92.22) 61.54,92.2 C364.1 ; C335.1 63.96,101.02 v3(63.96,101.02) ; v3(66.36,101.02) 66.46,100.91 C358.1 ; v3(59.16,101.02) 59.13,101.05 C337.1 ; v3(63.96,92.22) 63.96,92.21 C350.1 ; C332.1 64.76,91.73 v3(64.76,92.22) ; C339.1 66.71,95.07 v3(66.36,95.42) ; v3(66.36,100.22) 66.43,100.15 C352.1 ; v3(66.36,94.62) 66.67,94.31 C354.1
  TOP w0.381: v1(55.36,58.93) 55.37,58.92 CM12.1 ; CM4.1 55.37,71.47 v1(55.36,71.46) ; v1(52.95,58.93) 52.96,58.92 CM16.1 ; v1(47.74,63.46) 47.69,63.5 CM9.1 ; v1(57.76,58.93) 57.78,58.9 CM15.1 ; v1(47.74,67.06) CM3.1 ; v1(57.76,71.33) 57.78,71.36 CM13.1 ; v1(60.15,61.67) 60.69,61.67 CM6.1 ; CM2.1 v1(60.15,63.83)
  TOP w0.508: v1(58.88,71.45) CB7.2 58.8,72.17 CM13.1 ; CM7.1 v1(52.96,71.45)
  BOTTOM w0.356: U67.P18 63.56,92.62 v3(63.96,92.22) ; U67.U14 v3(66.36,95.42) ; U67.J9 v3(59.16,100.22) ; U67.M18 v3(61.56,92.22) ; U67.J10 v3(59.16,99.42) ; U67.U13 v3(66.36,97.02) ; U67.R18 64.36,92.62 v3(64.76,92.22) ; U67.U16 v3(66.36,93.82) ; U67.J15 v3(59.16,94.62) ; U67.U9 v3(66.36,100.22) ; U67.U17 v3(66.36,93.02) ; U67.U15 v3(66.36,94.62) ; U67.P8 v3(63.96,101.02) ; U67.U8 v3(66.36,101.02) ; U67.J11 v3(59.16,98.62) ; U67.J14 v3(59.16,95.42) ; U67.N8 v3(62.36,101.02) ; U67.J8 v3(59.16,101.02) ; U67.L18 v3(60.76,92.22)
  BOTTOM w0.381: U67.A7 v3(52.76,101.82) ; v3(54.36,102.62) 54.36,102.62 U67.C6 ; U67.E6 v3(55.96,102.62) ; U67.D7 v3(55.16,101.82) ; U67.B8 53.96,100.62 v3(53.56,101.02) ; v3(53.56,101.82) 53.96,101.42 U67.B7 ; U67.A8 v3(52.76,101.02) ; U67.F6 v3(56.76,102.62) ; U67.D8 v3(55.16,101.02) ; U67.D6 v3(55.16,102.62) ; U67.F8 v3(56.76,101.02) ; U67.B6 53.96,102.22 v3(53.56,102.62) ; U67.A6 v3(52.76,102.62) ; U67.E8 v3(55.96,101.02) ; U67.F7 v3(56.76,101.82) ; U67.E7 v3(55.96,101.82) ; U67.C8 v3(54.36,101.02) ; U67.C7 v3(54.36,101.82)
  vias: v1(47.73,60.3) v2(46.56,97.99) v2(47.32,99.52) v2(47.32,98.76) v2(47.32,97.99) v2(48.08,99.52) v2(48.08,98.76) v2(48.08,97.99) v2(48.84,99.52) v2(48.84,98.76) v2(48.84,97.99)
VDD_1V8_CDC: length 35.8
  TOP w0.508: CA51.1 141.6,147.97 v1(141.6,148.59) C30.1 141.37,149.52 140.42,150.47 R112.1 ; v1(147.32,138.58) 147.32,137.98 146.58,137.24 136.7,137.24 135.74,138.2 RZ12.2 135.74,140.23 132.33,143.64 132.33,150.62 133.88,152.17 134.84,152.17 135.34,151.66 CA48.1
  BOTTOM w0.203: U16.43 141.55,148.54 v1(141.6,148.59)
  BOTTOM w0.508: RZ168.2 v1(147.32,138.58)
VDD_A: length 32.1
  TOP w0.203: U66.46 99.77,88.13 v1(99.97,87.93) 99.77,87.73 U66.45 ; U66.17 92.29,81.85 91.84,81.4 91.84,81.28 v1(91.71,81.15) ; v1(99.97,84) 99.84,84.13 U66.36
  IN1 w0.508: v1(91.71,81.15) 91.71,83.48 92.35,84.12 99.85,84.12 v1(99.97,84) 99.97,83.54 100.21,83.31 100.74,83.31 101.24,83.82 101.24,84.23 101.51,84.49 101.51,87.24 100.74,88.01 100.05,88.01 v1(99.97,87.93)
  BOTTOM w0.508: C313.1 91.35,84.09 C317.1 91.35,81.51 v1(91.71,81.15) ; v1(99.97,84) 99.31,84 C314.1 99.11,85.14 99.3,85.33 C316.1 C315.1 99.92,87.88 v1(99.97,87.93) 100.15,87.93 100.76,88.54 FB34.1
VDD_BBAT: length 27
  TOP w0.381: v1(83.95,123.01) 84.05,123.01 J1.D37
  BOTTOM w0.508: v1(83.95,123.01) 81.74,125.22 77.11,125.22 76.12,126.21 76.12,142.44 D1.C
VDD_PLL_A_A: length 5.2
  TOP w0.203: 100.6,83.02 100.28,83.33 U66.34
  TOP w0.406: 100.6,83.02 100.77,82.84 C308.1
  TOP w0.508: FB31.1 104.15,82.84 C307.1 C308.1
VDD_PLL_P_A: length 5.4
  TOP w0.203: U66.42 99.77,86.53 99.85,86.61 100.74,86.61 101.05,86.93
  TOP w0.508: 101.05,86.93 101.37,87.25 C309.1 101.64,88.37 C310.1 101.66,89.5 FB32.1
VDDE_A: length 12.6
  TOP w0.203: v1(100.06,87.08) 99.81,87.08 99.66,86.93 U66.43 ; U66.1 91.18,88.93 90.58,89.53 v1(90.45,89.53)
  TOP w0.508: R538.1 R537.1 ; R537.1 R536.1 R535.1 v1(87.4,87.38) ; R537.1 v1(87.4,85.09) ; R534.2 v1(87.4,81.66) ; v1(87.4,88.52) R533.2 R532.2
  BOTTOM w0.508: C299.1 91.08,90.17 v1(90.45,89.53) 90.96,89.03 C298.1 ; v1(100.06,87.08) 100.32,87.08 100.57,87.34 C300.1 ; RZU28.2 v1(89.94,80.42)
  vias: v1(100.74,91.44) v1(101.37,91.44)
VIN_PWR_BAD_G: length 4.1
  TOP w0.107: RZ4.2 RZU4.1 112.62,158.12 112.79,157.95 Q5.G 114.27,157.35 RZU5.2
VIN_PWR_BAD_N: length 109.9
  TOP w0.107: v1(66.93,171.96) 59.05,171.96 58.7,171.6 RZ3.2 58.91,171.11 Q33.6 ; v1(113.03,154.31) 113.03,156.1 112.85,156.29 111.68,156.29 111.49,156.48 Q5.S 111.49,157.99 111.66,158.16 RZU4.2 111.02,159.38 106.93,159.38 97.79,150.24 v1(85.09,150.24) ; J1.L55 v1(101.1,133.48)
  IN1 w0.124: v1(113.03,154.31) 112.73,154.31 101.1,142.68 v1(101.1,133.48)
  IN3 w0.124: v1(66.93,171.96) 66.93,168.19 68.96,166.16 68.96,153.16 71.88,150.24 v1(85.09,150.24)
VIN_PWR_ON: length 158.5
  TOP w0.254: U6.10 130.03,160.44 RB6.2
  TOP w0.508: RZ8.1 v1(70.36,150.75) ; v1(85.09,148.21) 85.7,147.6 113.69,147.6 120.27,154.18 120.27,160.02 121.54,161.29 128.4,161.29 129.13,160.55 v1(129.29,160.55) RB6.2
  IN3 w0.508: v1(116.71,86.74) 115.98,87.48 115.98,96.34 113.97,98.35 113.97,101.95 118.06,106.05 119.84,106.05 124,110.21 124,131.24 125.78,133.02 125.78,140.87 126.27,141.35 126.27,151.47 126.62,151.82 126.62,152.91 126.11,153.42 126.11,158.75 127.91,160.55 v1(129.29,160.55)
  BOTTOM w0.508: RZ191.1 116.46,86.49 v1(116.71,86.74) ; v1(70.36,150.75) 70.36,149.63 72.47,147.52 84.4,147.52 v1(85.09,148.21)
VIN_PWR_ON_5V: length 2.7
  TOP w0.254: Q38.G v1(115.33,84.2)
  BOTTOM w0.254: v1(115.33,84.2) 115.49,84.37 RZ116.2 RZ191.2
VIN_PWR_ON_SRC: length 2.5
  TOP w0.508: RZ8.2 R674.1 68.35,152.56 68.18,152.73 Q34.G
VIN_SHUTDOWN_N: length 5.9
  TOP w0.107: RZ3.1 59.56,171.22 Q33.5 59.56,169.54 59.44,169.42 57.53,169.42 57.42,169.53 U75.4 57.42,171.16 R668.2
VIN_SHUTDOWN_Q: length 4.8
  TOP w0.254: R673.1 61.13,168.21 Q33.3 60.21,167 59.96,166.75 R669.2 59.56,166.85 Q33.2
06DPE_RSTN: length 4.7
  TOP w0.107: RZ85.2 C370.1 63.23,67.41 63.42,67.59 65.37,67.59 65.56,67.41 R622.2
06DPE_RSTN_R: length 2.6
  TOP w0.107: U70.36 59.4,66.26 60.15,67.01 RZ85.1
06INT_HOTPLUG: length 4.9
  TOP w0.107: U70.8 52.16,59.78 51.38,59 51.38,56.26 51.56,56.08 TP49.1
06PERSTN: length 8.7
  TOP w0.107: U70.37 59.19,66.66 60.68,68.15 C369.1 60.82,68.44 61.04,68.66 62.81,68.66 63.14,68.33 ; 63.14,68.33 63.14,68.35 63.45,68.66 65.1,68.66 R621.2 ; 63.14,68.33 RZ81.1
06REXT: length 5.9
  TOP w0.107: R634.1 47.83,74.14 47.83,71.37 48.21,70.99 48.21,69.56 48.32,69.46 U70.67
06REXT2: length 4.7
  TOP w0.107: U70.25 59.33,61.86 60.02,61.16 R635.1
06SM_CLK: length 4.2
  TOP w0.107: RZU32.1 61.19,71.29 59.26,69.36 59.26,68.85 59.06,68.66 U70.42
06SM_DATA: length 3.8
  TOP w0.107: U70.41 59.11,68.26 59.71,68.86 59.71,69.24 60.78,70.31 RZU33.1
06SPI_CS: length 17.4
  TOP w0.107: U70.6 51.36,59.72 50.41,58.77 50.41,55.37 50.09,55.05 50.09,50.77 51.13,49.73 51.13,46.56 52.02,45.67 SPI2.1
06SPI_SCK: length 8.8
  TOP w0.107: v1(50.9,52.91) RZ108.2 R637.1 50.9,54.95 50.9,58.87 51.76,59.73 U70.7
  BOTTOM w0.107: v1(50.9,52.91) 51.49,52.32 RZ111.2
06SPI_SDIO: length 14.8
  TOP w0.107: v1(50.52,48.72) 50.52,49.48 48.66,51.34 48.66,53.13 49.05,53.52 R629.1 R633.1 49.35,55.01 49.92,55.58 49.92,58.66 50.96,59.7 U70.5
  BOTTOM w0.107: RZ114.1 v1(50.52,48.72) RZ109.1
06SPI_SDIO1: length 1.1
  BOTTOM w0.107: RZ110.2 RZ109.2
06TESTEN: length 5.2
  TOP w0.107: R632.1 52.06,74.65 51.49,74.08 51.49,71.59 52.16,70.92 U70.59
06UART_RX: length 47.5
  TOP w0.107: U70.35 v1(59.51,65.86)
  IN3 w0.124: v1(38.29,78.77) 38.29,76.45 41.63,73.1 47.71,73.1 48.77,72.04 60.38,72.04 60.87,71.54 60.87,67.44 59.51,66.09 v1(59.51,65.86)
  BOTTOM w0.107: J13.4 26.29,76.45 28.6,78.77 v1(38.29,78.77)
06UART_TX: length 51.9
  TOP w0.107: R636.1 65.43,65.76 RZ89.2 63.93,65.86 v1(60.15,65.86) 59.73,65.45 59.34,65.45 59.33,65.46 U70.34
  IN3 w0.124: v1(39.05,78.77) 38.98,78.7 38.98,76.36 41.81,73.53 47.89,73.53 48.95,72.47 60.55,72.47 61.3,71.72 61.3,67.27 60.15,66.12 v1(60.15,65.86)
  BOTTOM w0.107: v1(39.05,78.77) 38.64,78.35 29.51,78.35 28.83,77.67 J13.3
06UPE_CLKREQN: length 5.2
  TOP w0.107: U70.65 49.76,70.73 49.55,70.94 49.38,70.94 48.99,71.33 48.99,72.81 48.72,73.08 R641.2 R638.2
06WP#: length 3.4
  TOP w0.107: SPI2.3 v1(54.69,48.21)
  BOTTOM w0.107: R648.2 RZU36.1 54.51,48.39 v1(54.69,48.21)
06XI: length 7.8
  TOP w0.107: X11.3 43.09,71.79 43.21,71.91 44.7,71.91 45.8,70.82 C371.2 45.83,70.14 46.81,69.16 47.32,69.16 47.83,68.66 U70.69
06XO: length 5.1
  TOP w0.107: U70.70 47.9,68.26 47.37,68.78 46.22,68.78 C371.1 45.14,69.86 X11.1
12DPE_CLKN0: length 77.9
  TOP w0.114: v1(78.05,105.24) 77.83,105.47 76.87,105.47 RZ37.2 ; v1(51.64,82.6) 51.41,82.37 50.9,82.37 40.97,72.44 40.97,68.94 42.3,67.6 43.04,67.6 RZ83.1
  IN1 w0.122: v1(51.64,82.6) 51.41,82.37 51.13,82.37 51,82.5 51,82.95 51.13,83.08 51.13,83.44 51,83.57 51,83.94 51.13,84.07 51.13,84.43 51,84.56 51,84.93 51.13,85.06 51.13,85.43 51,85.55 51,89.2 51.89,90.09 51.89,93.18 52.02,93.31 52.02,93.68 51.89,93.81 51.89,94.18 52.02,94.31 52.02,94.67 51.89,94.8 51.89,103.33 52.27,103.71 52.27,106.76 52.93,107.42 68.02,107.42 68.47,107.87 72.76,107.87 72.89,107.74 73.26,107.74 73.39,107.87 73.75,107.87 73.88,107.74 74.25,107.74 74.38,107.87 74.74,107.87 74.87,107.74 75.24,107.74 75.37,107.87 76.25,107.87 77.29,106.83 77.29,105.74 77.56,105.47 77.83,105.47 v1(78.05,105.24)
12DPE_CLKP0: length 77.9
  TOP w0.114: RZ33.2 76.87,105.73 77.83,105.73 v1(78.05,105.96) ; RZ80.1 42.99,67.86 42.41,67.86 41.92,68.34 41.92,68.54 41.67,68.79 41.48,68.79 41.22,69.04 41.22,69.69 41.36,69.82 41.36,70.18 41.22,70.32 41.22,70.67 41.36,70.81 41.36,71.17 41.22,71.3 41.22,72.34 42.24,73.35 42.43,73.35 42.68,73.6 42.68,73.79 42.93,74.04 43.13,74.04 43.38,74.3 43.38,74.49 49.01,80.12 49.2,80.12 49.45,80.37 49.45,80.56 49.7,80.81 49.9,80.81 50.15,81.07 50.15,81.26 51.01,82.12 51.41,82.12 v1(51.64,81.89)
  IN1 w0.122: v1(78.05,105.96) 77.83,105.73 77.67,105.73 77.55,105.85 77.55,106.93 76.35,108.13 68.37,108.13 67.91,107.67 52.83,107.67 52.02,106.86 52.02,103.81 51.64,103.43 51.64,90.2 50.75,89.31 50.75,82.39 51.03,82.12 51.41,82.12 v1(51.64,81.89)
12DPE_CLKREQN0: length 3.8
  TOP w0.107: v3(71.16,105.02) 70.31,105.87 70.31,105.87 69.42,106.76 R566.1
  BOTTOM w0.107: U67.AC3 v3(71.16,105.02)
12DPE_CLKREQN1: length 3.5
  TOP w0.107: v3(71.96,105.02) 71.77,105.21 71.63,105.21 71.2,105.64 R567.1
  BOTTOM w0.107: U67.AD3 v3(71.96,105.02)
12DPE_CLKREQN2: length 2.4
  TOP w0.107: v3(69.56,103.42) 69.53,103.45 68.38,103.45 68,103.07 R568.1
  BOTTOM w0.114: U67.AB5 v3(69.56,103.42)
12DPE_CLKREQN3: length 3.2
  TOP w0.107: R569.1 68.25,103.83 69.94,103.83 v3(70.36,103.42)
  BOTTOM w0.114: U67.AC5 v3(70.36,103.42)
12DPE_CLKREQN4: length 3.1
  TOP w0.107: v3(54.36,100.22) 53.54,100.22 53.35,100.03 R570.1
  BOTTOM w0.107: U67.C9 v3(54.36,100.22)
12DPE_CLKREQN5: length 4.4
  TOP w0.107: v3(55.16,100.22) 54.76,99.82 53.98,99.82 53.04,98.88 R571.1
  BOTTOM w0.107: U67.D9 v3(55.16,100.22)
12DPE_RSTN: length 5.4
  TOP w0.107: R563.1 50.04,103.53 49.82,103.75 C318.1 v1(48.92,104.52)
  BOTTOM w0.107: RZ182.1 v1(48.92,104.52)
12DPE_RXN0: length 62.2
  TOP w0.114: CM56.2 57.02,76.03 57.02,76.33 57.23,76.53 57.23,78.7 57.02,78.9 57.02,79.4 v1(56.79,79.63)
  IN3 w0.122: v3(63.96,88.22) 63.68,87.93 63.68,87.71 63.3,87.33 63.07,87.33 62.69,86.94 62.69,86.33 62.01,85.65 60.3,85.65 59.62,84.96 47.69,84.96 arc(47.54,84.9) 47.47,84.75 47.47,84.3 arc(47.56,84.1) 47.76,84.02 56.74,84.02 arc(57.1,83.87) 57.24,83.52 57.24,83.06 arc(57.1,82.72) 56.76,82.58 53.98,82.58 52,80.59 47.78,80.59 arc(47.58,80.51) 47.5,80.31 47.5,79.98 arc(47.59,79.75) 47.82,79.66 52.48,79.66 53.92,81.1 58.14,81.1 arc(58.52,80.95) 58.67,80.57 58.67,79.25 arc(58.51,78.85) 58.12,78.69 57.51,78.69 arc(57.16,78.83) 57.02,79.17 57.02,79.4 v1(56.79,79.63)
  BOTTOM w0.114: U67.P23 63.56,88.62 v3(63.96,88.22)
12DPE_RXN1: length 63.7
  TOP w0.114: CM50.2 53.1,77.81 53.41,78.13 53.41,78.31 53.24,78.49 v1(53.19,78.49)
  IN3 w0.122: v1(53.19,78.49) 53.42,78.26 53.42,78.13 53.29,78 49.81,78 arc(49.29,77.79) 49.07,77.26 49.07,75.62 arc(49.3,75.08) 49.83,74.85 66.57,74.85 67.72,76 73.89,76 arc(74.25,76.15) 74.4,76.5 74.4,76.91 arc(74.24,77.28) 73.87,77.44 68.46,77.44 arc(68.26,77.52) 68.17,77.72 68.17,78.13 arc(68.25,78.3) 68.42,78.37 73.26,78.37 arc(73.61,78.52) 73.75,78.87 73.75,79.32 arc(73.61,79.67) 73.25,79.82 68.27,79.82 66.95,81.13 66.95,83.9 65.43,85.42 65.43,86.87 65.3,86.99 65.3,87.16 v3(65.56,87.42)
  BOTTOM w0.114: v3(65.56,87.42) 65.16,87.82 U67.T24
12DPE_RXP0: length 62.2
  TOP w0.114: CM57.2 57.28,76.03 57.28,76.23 57.48,76.43 57.48,78.8 57.28,79 57.28,79.4 v1(57.51,79.63)
  IN3 w0.122: v3(63.16,88.21) 63.42,87.95 63.42,87.81 63.19,87.58 62.97,87.58 62.43,87.05 62.43,86.44 61.9,85.9 60.2,85.9 59.51,85.22 58.79,85.22 58.66,85.35 58.28,85.35 58.15,85.22 57.77,85.22 57.64,85.35 57.26,85.35 57.13,85.22 47.69,85.22 arc(47.36,85.08) 47.22,84.75 47.22,84.3 arc(47.38,83.92) 47.76,83.76 56.74,83.76 arc(56.92,83.69) 56.99,83.52 56.99,83.06 arc(56.92,82.9) 56.76,82.83 53.87,82.83 51.89,80.85 47.78,80.85 arc(47.4,80.69) 47.24,80.31 47.24,79.98 arc(47.41,79.58) 47.82,79.41 50.54,79.41 50.67,79.28 51.05,79.28 51.18,79.41 51.56,79.41 51.69,79.28 52.07,79.28 52.2,79.41 52.58,79.41 53.05,79.87 53.23,79.87 53.5,80.14 53.5,80.33 54.03,80.85 54.77,80.85 54.9,80.72 55.28,80.72 55.41,80.85 55.79,80.85 55.92,80.72 56.3,80.72 56.43,80.85 58.14,80.85 arc(58.34,80.77) 58.42,80.57 58.42,79.25 arc(58.33,79.03) 58.12,78.94 57.51,78.94 arc(57.34,79.01) 57.28,79.17 57.28,79.4 v1(57.51,79.63)
  BOTTOM w0.114: U67.N23 62.76,88.61 v3(63.16,88.21)
12DPE_RXP1: length 63.7
  TOP w0.114: v1(53.9,78.49) 53.82,78.49 53.67,78.33 53.67,78.2 CM51.2
  IN3 w0.122: v3(64.76,87.42) 64.83,87.42 65.05,87.2 65.05,86.89 65.18,86.76 65.18,85.31 65.98,84.51 65.98,84.33 66.25,84.06 66.43,84.06 66.7,83.79 66.7,83.23 66.57,83.1 66.57,82.72 66.7,82.59 66.7,81.02 68.16,79.56 73.25,79.56 arc(73.43,79.49) 73.5,79.32 73.5,78.87 arc(73.43,78.7) 73.26,78.63 68.42,78.63 arc(68.07,78.48) 67.92,78.13 67.92,77.72 arc(68.08,77.34) 68.46,77.19 73.87,77.19 arc(74.06,77.11) 74.14,76.91 74.14,76.5 arc(74.07,76.33) 73.89,76.25 67.61,76.25 66.47,75.11 65.81,75.11 65.68,75.24 65.3,75.24 65.17,75.11 64.79,75.11 64.66,75.24 64.27,75.24 64.15,75.11 51.7,75.11 51.57,75.24 51.19,75.24 51.06,75.11 50.68,75.11 50.55,75.24 50.17,75.24 50.04,75.11 49.83,75.11 arc(49.48,75.26) 49.33,75.62 49.33,77.26 arc(49.47,77.61) 49.81,77.75 50.56,77.75 50.69,77.62 51.07,77.62 51.2,77.75 53.4,77.75 53.67,78.02 53.67,78.26 v1(53.9,78.49)
  BOTTOM w0.114: U67.R24 64.36,87.82 v3(64.76,87.42)
12DPE_TXN0: length 61.7
  TOP w0.114: v1(55.6,78.5) 55.69,78.5 55.85,78.33 55.85,78.22 CM52.2
  IN3 w0.122: v1(55.6,78.5) 55.83,78.27 55.83,77.52 arc(55.74,77.3) 55.52,77.21 52.32,77.21 arc(51.91,77.04) 51.74,76.63 51.74,76.23 arc(51.91,75.81) 52.32,75.64 60.81,75.64 arc(61.21,75.72) 61.54,75.95 61.81,76.21 arc(62.14,76.43) 62.53,76.51 66.71,76.51 arc(67.1,76.67) 67.26,77.06 67.26,77.47 arc(67.12,77.81) 66.78,77.95 59.94,77.95 arc(59.75,78.03) 59.66,78.23 59.66,78.61 arc(59.75,78.81) 59.94,78.89 65.91,78.89 arc(66.34,79.07) 66.52,79.5 66.52,79.91 arc(66.35,80.32) 65.94,80.49 64.74,80.49 arc(64.46,80.61) 64.34,80.9 64.34,83.01 arc(64.16,83.44) 63.73,83.62 63.47,83.62 arc(63.06,83.45) 62.89,83.03 62.89,80.87 arc(62.78,80.61) 62.51,80.49 60.63,80.49 arc(60.34,80.61) 60.22,80.9 60.22,84.35 60.68,84.81 63.09,84.81 63.83,85.55 63.83,86.11 63.78,86.16 63.78,86.43 v3(63.96,86.62)
  BOTTOM w0.114: v3(63.96,86.62) 63.56,87.02 U67.P25
12DPE_TXN1: length 60
  TOP w0.114: CM54.2 54.61,76.03 54.61,79.4 v1(54.38,79.63)
  BOTTOM w0.114: v1(54.38,79.63) 54.56,79.45 54.56,78.23 54.32,77.99 40.14,77.99 arc(39.7,77.81) 39.51,77.37 39.51,76.07 arc(39.69,75.64) 40.12,75.46 52.1,75.46 53.16,76.53 58.37,76.53 59.34,77.5 59.84,77.5 arc(60.2,77.64) 60.35,78 60.35,78.89 arc(60.21,79.22) 59.88,79.36 58.53,79.36 arc(58.36,79.43) 58.29,79.6 58.29,80.49 arc(58.37,80.67) 58.55,80.75 62.43,80.75 62.99,81.31 62.99,83.69 64.89,85.59 64.89,86.1 65,86.22 U67.T26
12DPE_TXP0: length 61.6
  TOP w0.114: CM53.2 56.11,78.17 56.11,78.33 56.28,78.5 v1(56.31,78.5)
  IN3 w0.122: v3(63.16,86.62) 63.33,86.62 63.53,86.42 63.53,86.06 63.58,86 63.58,85.65 62.99,85.06 60.58,85.06 59.97,84.45 59.97,83.23 59.84,83.1 59.84,82.72 59.97,82.59 59.97,82.21 59.84,82.08 59.84,81.7 59.97,81.57 59.97,80.9 arc(60.16,80.43) 60.63,80.24 62.51,80.24 arc(62.96,80.43) 63.14,80.87 63.14,83.03 arc(63.24,83.27) 63.47,83.36 63.73,83.36 arc(63.98,83.26) 64.08,83.01 64.08,80.9 arc(64.28,80.43) 64.74,80.24 65.94,80.24 arc(66.17,80.14) 66.27,79.91 66.27,79.5 arc(66.16,79.25) 65.91,79.14 59.94,79.14 arc(59.57,78.99) 59.41,78.61 59.41,78.23 arc(59.57,77.86) 59.94,77.7 66.78,77.7 arc(66.94,77.63) 67.01,77.47 67.01,77.06 arc(66.92,76.85) 66.71,76.76 62.53,76.76 arc(62.04,76.67) 61.63,76.39 61.36,76.13 arc(61.11,75.96) 60.81,75.9 60.24,75.9 60.11,76.02 59.73,76.02 59.6,75.9 59.22,75.9 59.09,76.02 58.71,76.02 58.58,75.9 52.32,75.9 arc(52.09,75.99) 51.99,76.23 51.99,76.63 arc(52.09,76.86) 52.32,76.96 53.6,76.96 53.73,76.83 54.11,76.83 54.24,76.96 54.62,76.96 54.75,76.83 55.14,76.83 55.27,76.96 55.52,76.96 arc(55.92,77.12) 56.08,77.52 56.08,78.27 v1(56.31,78.5)
  BOTTOM w0.114: v3(63.16,86.62) 62.76,87.02 U67.N25
12DPE_TXP1: length 60
  TOP w0.114: CM55.2 54.86,76.03 54.86,79.4 v1(55.09,79.63)
  BOTTOM w0.114: v1(55.09,79.63) 54.99,79.63 54.81,79.45 54.81,78.13 54.42,77.74 40.14,77.74 arc(39.87,77.63) 39.77,77.37 39.77,76.07 arc(39.87,75.82) 40.12,75.72 51.99,75.72 53.06,76.78 55.23,76.78 55.37,76.92 55.73,76.92 55.86,76.78 56.22,76.78 56.36,76.92 56.71,76.92 56.85,76.78 57.21,76.78 57.34,76.92 57.7,76.92 57.84,76.78 58.27,76.78 59.23,77.75 59.84,77.75 arc(60.02,77.82) 60.1,78 60.1,78.89 arc(60.03,79.05) 59.88,79.11 58.53,79.11 arc(58.18,79.25) 58.04,79.6 58.04,80.49 arc(58.19,80.85) 58.55,81 59.18,81 59.31,81.14 59.67,81.14 59.81,81 60.16,81 60.3,81.14 60.66,81.14 60.79,81 62.33,81 62.74,81.41 62.74,83.8 63.68,84.74 63.68,84.94 63.93,85.19 64.13,85.19 64.63,85.69 64.63,86.1 64.52,86.22 U67.R26
422RX+: length 13.1
  TOP w0.254: v1(62.97,191.01) 63.73,190.25 64.77,190.25 65.68,189.33 R254.2 65.65,188.56 U36.6
  BOTTOM w0.254: v1(62.97,191.01) R251.1 62.97,194.08 62.55,194.5 NMEA0183.5
422RX-: length 15.1
  TOP w0.254: v1(61.49,191.01) 63.02,189.48 64.11,189.48 64.36,189.23 R253.1 64.38,188.58 U36.7
  BOTTOM w0.254: NMEA0183.2 61.49,192.62 R251.2 v1(61.49,191.01)
422TX+_485+: length 11.3
  TOP w0.254: NMEA0183.6 64.55,191.9 R249.1 v1(64.54,190.98)
  BOTTOM w0.254: U38.6 64.39,188.57 R259.2 64.36,190.8 v1(64.54,190.98)
422TX-_485-: length 12.5
  TOP w0.254: NMEA0183.8 68.55,196.69 66.01,194.16 R249.2 66.01,191.03 v1(66.04,191.01)
  BOTTOM w0.254: U38.7 65.66,188.57 R257.1 65.68,190.65 v1(66.04,191.01)
1812_RST_N: length 2.4
  BOTTOM w0.107: U67.A2 53.02,105.56 RZ180.1
1812DEBUG27: length 5.2
  TOP w0.107: v3(71.96,87.42) 72.94,86.44 74.47,86.44 RZ59.1 R575.1
  BOTTOM w0.107: U67.AD24 v3(71.96,87.42)
1812DEBUG27_P: length 1.1
  TOP w0.107: R585.1 RZ59.2
1812DEBUG28: length 1.3
  TOP w0.107: TP48.1 73.56,87.42 v1(73.56,87.42)
  BOTTOM w0.107: U67.AF24 v1(73.56,87.42)
1812GPIO5: length 4.7
  TOP w0.107: RZ60.1 R578.1 72.29,85.34 72.4,85.46 72.4,86.18 v3(71.96,86.62)
  BOTTOM w0.107: U67.AD25 v3(71.96,86.62)
1812GPIO5_P: length 1.5
  TOP w0.107: RZ60.2 73.69,81.81 R583.1
1812INT_HOTPLUG: length 1.2
  TOP w0.107: v3(69.56,86.62) 69.6,86.58 TP47.1
  BOTTOM w0.107: U67.AA25 v3(69.56,86.62)
1812SMCL: length 2.6
  BOTTOM w0.107: RZU44.1 51.46,106.81 52.05,106.22 U67.A1
1812SMDA: length 3.9
  BOTTOM w0.107: RZU43.1 51.08,107.95 52.27,106.76 53.42,106.76 U67.B1
1812SPI_CS: length 13.2
  TOP w0.107: SPI1.1 70.64,75.95 v1(70.21,75.51)
  IN1 w0.124: v3(71.96,85.82) 71.96,77.27 v1(70.21,75.51)
  BOTTOM w0.107: U67.AD26 v3(71.96,85.82)
1812SPI_SCK: length 8.7
  BOTTOM w0.107: U67.AB26 69.96,84.77 69.65,84.46 RZ196.2 69.65,82.7 R606.1 69.09,82.4 69.09,81.13 68.61,80.64 67.23,80.64 67.03,80.44 RZ65.2
1812SPI_SCK_P: length 1.4
  BOTTOM w0.107: R610.1 70.61,82.8 RZ196.1
1812SPI_SDIO: length 18.3
  TOP w0.107: RZ68.1 v1(75.34,76.07)
  IN1 w0.124: v1(72.92,83.64) 73.69,83.64 73.96,83.36 73.96,77.44 v1(75.34,76.07)
  BOTTOM w0.107: R574.1 72.01,83.92 71.65,83.57 71.65,80.31 RZ197.1 ; R574.1 72.29,85.02 72.36,85.09 U67.AE26 ; R574.1 72.64,83.92 v1(72.92,83.64) 73.2,83.92 RZ195.1
1812SPI_SDIO1: length 1.2
  BOTTOM w0.107: RZ197.2 RZ198.2
1812SPI_SDIO_P: length 1.4
  BOTTOM w0.107: R587.1 73.69,81.81 RZ195.2
1812TESTEN: length 4.7
  TOP w0.107: v3(70.36,104.22) 69.55,105.03 69.55,105.99 68.28,107.26 R579.1
  BOTTOM w0.107: U67.AB4 v3(70.36,104.22)
1812UART_TX_P: length 1.1
  BOTTOM w0.107: R615.1 RZ193.1
1812WP#: length 3.1
  TOP w0.107: SPI1.3 R618.2 RZU29.1
1812XI: length 6
  BOTTOM w0.107: U67.AC1 70.76,108.35 C319.2 69.64,109.47 69.64,111.04 69.76,111.17 X10.3
1812XO: length 5
  BOTTOM w0.107: U67.AC2 70.76,105.43 71.18,105.85 71.18,108.3 C319.1 71.46,108.93 71.69,109.16 X10.1
6408_INT#: length 2.7
  TOP w0.107: RZU31.2 RB54.1 124.85,71.98 U14.11
9633_HPD: length 7.1
  TOP w0.107: U66.40 v1(100.23,85.73)
  BOTTOM w0.107: Q55.G 103.15,86.85 RZU45.2 103.12,86.39 R504.1 102.01,85.47 101.75,85.22 100.49,85.22 100.23,85.48 v1(100.23,85.73)
51770_AGND: length 7.5
  TOP w0.279: U83.17 17.44,110.86 v1(17.09,111.2)
  TOP w0.508: RZ687.1 15.37,106.58 v1(15.27,106.48) ; C460.1 v1(20.09,111.89)
  BOTTOM w0.508: v1(15.27,106.48) 14.86,106.88 14.86,107.62 R752.1 14.05,108.43 14.05,110.31
  vias: v1(9.47,113.74) v1(9.47,112.47) v1(9.47,111.2) v1(10.74,113.74) v1(10.74,112.47) v1(10.74,111.2) v1(12.01,113.74) v1(12.01,112.47) v1(12.01,111.2) v1(13.28,113.74) v1(13.28,112.47) v1(13.28,111.2) v1(14.55,113.74) v1(14.55,112.47) v1(14.55,111.2) v1(15.82,113.74) v1(15.82,112.47) v1(15.82,111.2) v1(17.09,113.74) v1(17.09,112.47) v1(18.36,113.74) v1(18.36,112.47) v1(18.36,111.2)
51770_ATRK: length 2.2
  TOP w0.279: U83.16 16.94,108.82 v1(17.3,108.46)
  BOTTOM w0.381: C477.2 17.3,108.98 v1(17.3,108.46)
51770_BIAS: length 4.6
  TOP w0.279: U83.1 9.44,108.88 9.22,108.66 8.71,108.66
  TOP w0.508: RZ27.2 RZU19.2 7.91,109.79 CA64.1 8.71,108.66
51770_COMP: length 2.8
  TOP w0.279: v1(18.03,108.46) 17.94,108.56 U83.18
  BOTTOM w0.381: R747.2 18.03,107.8 v1(18.03,108.46) C475.2
51770_IMONOUT: length 2.1
  TOP w0.279: U83.6 v1(11.94,108.41)
  BOTTOM w0.381: R748.1 11.94,109.24 v1(11.94,108.41)
51770_MODE: length 3.7
  TOP w0.279: U83.12 14.94,108.84 14.86,108.76 14.86,108.28 15.6,107.54 RZ687.2
  TOP w0.508: RZ687.2 RB30.1
51770_VCC: length 22.8
  TOP w0.279: U83.31 12.94,116.88 12.56,117.26 CA60.1
  TOP w0.508: v1(11.51,106.58) RB29.2 RZ31.1 R741.1
  IN3 w0.508: v1(11.51,106.58) 10.9,107.19 9.17,107.19 8.08,108.28 8.08,116.03 9.47,117.42 11.65,117.42 v1(12.28,118.06) v1(12.9,118.06)
-SPKOUT: length 6.5
  BOTTOM w0.508: BUZZ1.2 8.07,197.19 CA117.1 10.53,197.19 11.18,197.84 Q15.C
ACC_ON: length 270.1
  IN3 w0.254: v1(8.53,82.17) 9.3,82.93 20.29,82.93 24.12,79.1 35.13,79.1 36.02,78.21 36.02,71.19 42.82,64.38 42.82,60.58 46.13,57.28 49.81,57.28 50.93,56.16 67.61,56.16 72.28,51.49 76.54,51.49 77.62,52.56 78.8,52.56 87.67,52.56 90.26,55.15 93.3,55.15 98.33,60.17 104.95,60.17 107.21,57.91 110.62,57.91 v1(112.12,59.41)
  BOTTOM w0.254: R86.1 140.79,63.7 137.08,67.41 132.13,67.41 131.11,68.43 115.47,68.43 114.45,67.41 114.45,60.81 113.06,59.41 v1(112.12,59.41) ; v1(8.53,82.17) 7.16,82.17 3.91,85.41 3.91,97.25 1.4,99.77 1.4,165.23 5.13,168.96 5.13,173.56 3.81,174.88 D58.C
ACC_ON#: length 4.4
  TOP w0.203: Q10.D 144.65,66.4 144.55,66.3 U13.1
  TOP w0.254: Q10.D v1(146.84,66.4)
  BOTTOM w0.254: R85.1 v1(146.84,66.4)
ACC_ON_R: length 6.7
  TOP w0.203: Q10.G 148.71,65.75 148.77,65.68 R87.1 v1(149.48,64.9)
  BOTTOM w0.254: v1(149.48,64.9) 146.66,64.9 R86.2
ACOK_CON: length 135.4
  TOP w0.107: v1(96.93,104.52) 96.93,107.85 R1482.1 RZU20.1 94.16,108.48 93.91,108.73 U91.1
  IN1 w0.124: 157.61,27.81 156.56,27.81 155.34,29.03 155.34,33.51 148.78,40.07 141.31,40.07 139.41,41.97 139.41,47.18 138.69,47.9 138.69,52.31 139.29,52.91 139.29,56.92 142.35,59.98 142.35,63.59 v1(143.66,64.9)
  BOTTOM w0.107: 157.61,27.81 157.61,26.8 158.09,26.31 Z16.2 ; v1(143.66,64.9) 140.23,64.9 137.19,67.94 132.49,67.94 131.85,68.58 131.85,70.99 131.09,71.75 127.66,71.75 124.1,75.31 120.04,75.31 118.9,76.45 113.87,76.45 107.75,82.58 107.75,91.44 106.83,92.35 106.83,99.57 104.44,101.96 102.67,101.96 101.35,103.28 99.01,103.28 97.76,104.52 v1(96.93,104.52)
ACOK_CON_OR: length 2.5
  TOP w0.254: U91.4 90.31,110.03 C894.1 90.26,108.85 R1479.1
ACOK_CON_OR_CR: length 6.3
  TOP w0.254: C894.2 88.8,109.98 D65.C 86.49,110.21 R1478.1 85.13,110.21 84.73,109.82 U90.3
ACOK_OR_RISING: length 91
  TOP w0.107: U12.4 v1(84.99,105.01) ; RZ6.2 v1(126.9,153.57)
  IN3 w0.124: v1(126.9,153.57) 127.21,153.26 127.21,151.78 126.81,151.38 126.81,131.7 124.44,129.34 124.44,110.02 119,104.58 v1(119,104.01)
  BOTTOM w0.107: v1(119,104.01) 112.98,104.01 111.56,102.59 103.17,102.59 100.41,105.36 94.46,105.36 93.37,104.27 85.74,104.27 v1(84.99,105.01)
ACOK_WOL_FB: length 25.5
  TOP w0.254: RZ30.2 RZ28.2 v1(80.19,110.36) ; RZU20.2 94.93,109.38 94.9,109.38 v1(94.51,108.99) 94.12,109.38 U91.2 93.28,109.38 92.86,108.97 92.86,106.55 93.12,106.3 U9.2 94.39,106.3 94.61,106.53 RZU24.2
  BOTTOM w0.254: v1(94.51,108.99) 94.26,108.74 88.87,108.74 88.16,108.03 85.55,108.03 85.12,107.59 82.96,107.59 v1(80.19,110.36)
ACOK_WOL_OR: length 2.6
  TOP w0.254: U9.4 90.3,106.95 C10.1 90.28,105.8 R43.1
ACOK_WOL_OR_CR: length 5.9
  TOP w0.254: C10.2 87.66,106.93 D2.C 86.54,108.05 R42.1 85.2,108.05 84.73,108.52 U90.1
