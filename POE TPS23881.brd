# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ACOK_WOL_RISING: length 8.3
  TOP w0.107: U90.6 81.21,108.52 RZ30.1 ; RZ30.1 81.15,106.58 81.42,106.31 U12.1 82.69,106.31 82.83,106.17 82.83,105.79 82.7,105.66 U12.2 ; RZ30.1 RZ28.1 81.24,109.82 U90.4
ALERT: length 6.3
  TOP w0.254: NMEA0183.3 58.55,196.34 56.77,194.56 TP60.1
ASM1806_GPIO5: length 5.8
  TOP w0.107: U70.2 49.76,59.66 49.48,59.39 49.33,59.39 R631.1 47.83,58.22 47.7,58.09 47.7,56.31 R630.1
ASM_VCC33: length 50.2
  TOP w0.203: CA80.1 49.4,58.57 50.56,59.73 U70.4
  TOP w0.229: U70.63 50.56,70.88 49.9,71.54 v1(49.86,71.54) ; U70.39 59.07,67.46 60.2,68.58 v1(60.2,68.78)
  TOP w0.305: v3(67.96,89.02) 67.94,89.03 CB17.1 ; CB18.1 68.73,89.05 v3(68.76,89.02)
  TOP w0.381: CB29.1 64.1,76.67 R608.1 ; CB29.1 64.1,74.54 64.41,74.22 ; CB29.1 64.74,75.39 65.3,75.95 SPI1.8 ; v1(48.79,58.2) CA80.1 ; v1(49.86,71.54) CA72.1 ; R637.2 v1(51.87,54.31) ; v1(60.2,68.78) 60.63,69.22 CA73.1
  TOP w0.508: v1(46.14,46.3) CA88.1 SPI2.8 ; R630.2 v1(48.21,54.18) ; 64.41,74.22 65.99,72.64 69.95,72.64 72.29,74.98 75.72,74.98 76.07,75.34 76.07,76.76 75.62,77.22 R607.1 R618.1 v1(75.34,78.49) ; R578.2 72.47,82.96 v1(72.92,82.96) ; R638.1 v1(48.46,76.28) ; R645.1 v1(45.19,47.6) ; 74.85,83.95 v1(74.85,83.24) ; R629.2 v1(49.35,51.89)
  BOTTOM w0.305: U67.AA9 v3(69.56,100.22) ; v1(49.63,95.45) R589.2 ; U67.AA8 v3(69.56,101.02)
  BOTTOM w0.381: v3(54.36,91.42) 54.76,91.82 U67.C19 ; U67.A19 53.16,91.82 v3(52.76,91.42) ; U67.B19 53.96,91.82 v3(53.56,91.42) ; U67.F19 57.16,91.82 v3(56.76,91.42) ; v3(55.16,91.42) 55.56,91.82 U67.D19 ; U67.W22 v3(67.96,89.02) ; U67.E19 56.36,91.82 v3(55.96,91.42) ; U67.Y22 v3(68.76,89.02)
  BOTTOM w0.508: R606.2 v1(69.6,81.28) ; Q29.S v1(40.56,83.74) ; R574.2 v1(72.92,82.96)
  vias: v1(43.84,83.82) v1(43.84,83.19) v1(44.6,83.82) v1(44.6,83.19) v1(49.73,46.94)
AUD_MCLK01_CDC: length 7.4
  BOTTOM w0.107: RZ155.2 135.13,150.11 135.34,149.9 C916.1 136.53,149.61 138.18,147.96 139.04,147.96 139.15,147.85 U16.37
AUDIO_CODEC_INT: length 2.8
  TOP w0.107: R112.2 140.31,149 v1(140.46,148.84)
  BOTTOM w0.107: RZ156.2 140.08,149.22 v1(140.46,148.84) 140.35,148.73 U16.40
AUDIO_CPN1: length 2.8
  BOTTOM w0.203: C43.2 139.23,140.25 139.51,140.53 140.02,140.53 140.35,140.86 U16.21
AUDIO_CPN2: length 2.4
  BOTTOM w0.203: C45.2 142.46,139.99 141.55,140.9 U16.18
AUDIO_CPN_VEE: length 1.6
  BOTTOM w0.203: C47.1 136.84,143.38 U16.27
AUDIO_CPP1: length 2.3
  BOTTOM w0.203: U16.20 140.75,140.41 C43.1
AUDIO_CPP2: length 2.2
  BOTTOM w0.203: C45.1 141.52,140.04 141.15,140.41 U16.19
AUDIO_CPP_VPP: length 2.6
  BOTTOM w0.203: 138.51,141.01 139.15,141.65 U16.24
  BOTTOM w0.508: 138.51,141.01 137.88,140.38 C46.1
AUDIO_LDO_EN: length 3
  BOTTOM w0.203: U16.44 141.95,148.17 142.24,148.46 142.24,148.77 142.44,148.97 143.31,148.97 143.51,149.17 R114.2
AUDIO_MIC1P: length 12.1
  IN3 w0.508: v1(144.02,141.1) 144.02,141.48 144.53,141.99 144.53,145.41 145.03,145.92 147.07,145.92 148.84,147.7 v1(148.84,148.34)
  BOTTOM w0.203: U16.13 143.55,141.56 v1(144.02,141.1)
  BOTTOM w0.381: C44.2 v1(148.84,148.34)
AUDIO_MIC_1P: length 8.2
  BOTTOM w0.381: AUDIO1.5 156.32,150.11 154.31,150.11 153.67,149.48 R1493.1 153.01,149.2 152.65,148.84 150.96,148.84 C44.1
AUDIO_MICBIAS: length 8.1
  TOP w0.381: v1(151.38,149.48) 151.76,149.48 152.27,148.97 152.27,146.67 151.76,146.16 v1(150.5,146.16)
  BOTTOM w0.381: v1(150.5,146.16) 149.99,146.16 149.97,146.18 RZ164.1 ; R1493.2 v1(151.38,149.48) CA14.1
AUDIO_MICBIAS_C: length 4.3
  BOTTOM w0.203: U16.4 144.97,145.78 145.37,146.18 145.95,146.18
  BOTTOM w0.381: RZ164.2 145.95,146.18
AUDIO_VREF1: length 2.7
  BOTTOM w0.203: 145.28,142.61 145.01,142.88 144.83,142.88 144.73,142.98 U16.11
  BOTTOM w0.508: CA15.1 146.02,141.86 145.28,142.61
AUDIO_VREF2: length 3.1
  BOTTOM w0.203: 144.78,142.05 144.65,142.18 144.65,142.37 144.44,142.58 U16.12
  BOTTOM w0.508: CA16.1 146.12,140.72 144.78,142.05
AUDIO_VREF_DAC: length 5.8
  BOTTOM w0.203: 145.88,143.04 145.58,143.04 145.36,143.26 144.97,143.26 144.85,143.38 U16.10
  BOTTOM w0.508: RZ166.2 148.84,142.11 148.11,142.85 C54.1 147.41,143.26 147.19,143.04 CA132.1 145.88,143.04
AUTOPWON: length 32.4
  TOP w0.107: RZ115.1 139.34,44.96 139.85,45.47 139.85,61.21 138.81,62.26 134.24,62.26 v1(133.5,62.99) ; U13.40 v1(132.87,70.3)
  IN1 w0.124: v1(132.87,70.3) 132.66,70.09 132.66,63.83 v1(133.5,62.99)
BAT_CONN: length 2.1
  BOTTOM w0.508: BAT1.2 70.78,143.88 R23.1
BAT_CONN_LIM: length 1.7
  BOTTOM w0.508: R23.2 D1.A2
BRD_SEL: length 2.9
  TOP w0.107: U6.11 128.17,158.83 RB9.2 R36.1
BT_WAKE_AP_M2E_CON: length 4.6
  BOTTOM w0.107: R190.1 135.06,133.6 135.13,133.67 Q52.6 135.62,133.36 136.99,132 WIFI1.20
BTN_OOB: length 2.1
  BOTTOM w0.107: RZ190.2 152.79,90.2 OOB1.9
BUTTON_POWER_ON_N: length 20.3
  TOP w0.107: U6.2 132.58,156.82 132.69,156.72 TP12.1 133.73,156.59 RB13.2 133.32,155.55 133.1,155.32 133.1,153.54 131.44,151.89 119.89,151.89 v1(119.63,152.15)
  BOTTOM w0.107: RZ152.2 v1(119.63,152.15)
BUTTON_POWER_ON_N_CON: length 183.6
  IN1 w0.124: v1(150.9,90.04) 153.19,87.76 153.19,81.03 149.76,77.6 149.76,68.2 148.62,67.06 145.06,67.06 142.1,64.1 142.1,60.08 139.04,57.03 139.04,53.01 138.44,52.41 138.44,47.79 139.16,47.08 139.16,41.79 141.12,39.82 148.67,39.82 154.99,33.5 154.99,25.2 151.89,22.1 v1(151.13,22.1)
  IN3 w0.124: v1(128.4,152.53) 128.4,151.4 127.98,150.98 127.98,141.51 128.24,141.25 128.24,139.9 127.92,139.58 127.92,126.69 128.8,125.81 128.8,123.44 131.64,120.6 131.64,115.14 136.55,110.24 142.32,110.24 146.35,106.2 147.37,106.2 147.79,105.78 147.79,102.13 150.56,99.36 150.56,96.66 151.43,95.78 151.43,90.58 v1(150.9,90.04)
  BOTTOM w0.107: RZ190.1 v1(150.9,90.04) ; v1(151.13,22.1) RB66.2 152.21,21.36 CA153.1 156.23,21.37 PWRBTN1.3 ; RZ151.1 121.51,152.93 122.56,151.89 127.76,151.89 v1(128.4,152.53)
BUTTON_POWER_ON_N_KEY: length 10.3
  BOTTOM w0.107: 118.5,153.9 118.56,153.96 PSON1.2 PSON1.1 ; 118.5,153.9 C132.1 ; 118.5,153.9 Z7.2 ; 118.5,153.9 RZ152.1 RZ151.2
CAM0_PWDN: length 44.3
  TOP w0.107: J14.93 v1(117,156.59)
  TOP w0.127: v1(96.14,136.78) 96.14,133.3 J1.L49
  IN1 w0.124: v1(117,156.59) 113.85,156.59 110.67,153.42 108.71,153.42 97.69,142.39 97.69,138.33 v1(96.14,136.78)
CAM0_RST: length 79.6
  TOP w0.107: J14.95 v1(117.5,163.73) ; J1.L5 53.3,133.74 54.38,134.82 v1(55.37,134.82)
  IN1 w0.124: v1(117.5,163.73) 117.5,163.02 114.92,160.44 109.87,160.44 92.18,142.75 68.71,142.75 62.02,136.06 56.6,136.06 v1(55.37,134.82)
CAM1_PWDN: length 101.3
  TOP w0.107: J14.90 v1(116,173.23) ; J1.F10 58,124.9 v1(57.76,124.66)
  IN1 w0.124: v1(116,173.23) 116,166.62 114.93,165.55 114.93,162.84 114.49,162.39 111.77,162.39 111.35,161.97 109.58,161.97 91.66,144.05 68.19,144.05 61.48,137.34 56.04,137.34 53.34,134.65 53.34,133.02 53.92,132.44 53.92,131.13 53.52,130.73 53.52,126.09 55.58,124.03 57.12,124.03 v1(57.76,124.66)
CAM1_RST: length 98.7
  TOP w0.107: v1(56.9,124.66) 57.1,124.87 J1.F9 ; J14.92 v1(116.5,172.72)
  IN1 w0.124: v1(56.9,124.66) 56.39,125.17 55.04,125.17 53.95,126.26 53.95,130.56 54.35,130.96 54.35,132.62 53.77,133.2 53.77,134.47 56.21,136.91 61.66,136.91 68.35,143.6 91.82,143.6 109.76,161.55 111.53,161.55 111.95,161.97 115.23,161.97 116.5,163.23 v1(116.5,172.72)
CAM_AVDD_EN: length 69.8
  TOP w0.107: v1(102.28,126.02) 102.2,125.94 J1.F56 ; v1(131.9,167) 131.9,168.4 136.4,172.9 RZ2.1
  IN1 w0.124: v1(131.9,167) 131.9,164.92 124.99,158.01 124.99,156.59 122.44,154.04 114.67,154.04 112.64,152.01 111.65,152.01 104.78,145.14 104.78,139.83 102.11,137.16 102.11,131.83 101.26,130.98 101.26,128.35 101.73,127.89 101.73,127.28 102.28,126.73 v1(102.28,126.02)
CAM_BACKLIGHT_PWM: length 38.7
  TOP w0.107: J14.109 v1(121,163.78) ; RZ18.1 v1(102.87,140.08)
  BOTTOM w0.107: v1(102.87,140.08) 102.87,141.07 104.65,142.85 104.65,153.37 109.53,158.25 109.53,161.22 110.62,162.31 117.86,162.31 119.38,163.83 120.95,163.83 v1(121,163.78)
CAM_ERROR1: length 79.3
  TOP w0.107: v3(62.52,133.5) 62.52,133.04 J1.L15 ; J14.76 v1(112.5,172.72)
  IN1 w0.124: v1(112.5,172.72) 112.5,172.13 114.66,169.98 114.66,166.7 110.94,162.98 109.17,162.98 91.47,145.29 67.69,145.29 64.16,141.76 v1(63.6,141.76)
  IN3 w0.124: v3(62.52,133.5) 62.52,140.67 v1(63.6,141.76)
CAM_ERROR2: length 90.9
  TOP w0.107: v1(52.7,135.71) 55.73,135.71 56.9,134.54 J1.L9 ; J14.78 v1(113,173.23)
  IN1 w0.124: v1(52.7,135.71) 53.26,135.71 55.68,138.13 60.89,138.13 67.8,145.04 91.58,145.04 109.27,162.73 111.04,162.73 114.91,166.6 114.91,170.08 113,171.99 v1(113,173.23)
CAM_ERROR3: length 102.5
  TOP w0.107: J14.84 v1(114.5,172.72) ; J1.A7 v1(55.1,118.52)
  IN1 w0.124: v1(55.1,118.52) 55.1,118.81 54.69,119.23 53.9,119.23 53.08,120.04 53.08,132.16 52.22,133.02 52.22,134.32 55.79,137.88 60.99,137.88 67.9,144.79 91.68,144.79 109.37,162.48 111.15,162.48 115.16,166.49 115.16,170.21 114.5,170.87 v1(114.5,172.72)
CAM_ERROR4: length 88.3
  TOP w0.107: J1.L4 52.4,133.17 v1(52.7,133.47) ; J14.86 v1(115,173.23)
  IN1 w0.124: v1(52.7,133.47) 52.7,134.37 55.96,137.63 61.1,137.63 68,144.53 91.79,144.53 109.48,162.23 111.25,162.23 111.67,162.65 114.39,162.65 114.68,162.94 114.68,165.65 115.41,166.38 115.41,170.31 115,170.73 v1(115,173.23)
CAM_FRSYNC1: length 52.2
  TOP w0.107: J1.A62 v1(107.4,118.52) ; v1(115.7,158.88) 115,159.58 J14.85
  IN3 w0.124: v1(107.4,118.52) 107.4,120.61 107.82,121.03 107.82,122.17 108.08,122.43 108.08,123.57 107.82,123.83 107.82,124.94 106.96,125.81 106.96,129.16 107.72,129.92 107.72,131.16 108.1,131.54 108.1,137.54 108.81,138.25 108.81,146.63 109.75,147.57 109.75,150.62 111.02,151.89 111.02,154.2 v1(115.7,158.88)
CAM_FRSYNC2: length 57
  TOP w0.107: J1.F59 v1(104.9,126.02) ; J14.98 v1(118,173.23)
  IN3 w0.124: v1(118,173.23) 118,171.14 117.33,170.46 117.33,168.07 114.66,165.4 114.66,161.5 113.48,160.32 110.72,160.32 106.65,156.25 106.65,141.24 105.8,140.39 105.8,136.75 105.32,136.27 105.32,131.2 105.16,131.04 105.16,130.12 104.9,129.87 v1(104.9,126.02)
CAM_FRSYNC3: length 51.5
  TOP w0.107: J1.E59 v1(104.7,124.52) ; v1(106.17,148.97) 106.43,149.22 113.41,149.22 118,153.81 J14.97
  IN3 w0.124: v1(106.17,148.97) 106.17,141.3 105.44,140.56 105.44,137.07 104.42,136.05 104.42,131.39 104.27,131.24 104.27,130.36 104.42,130.21 104.42,124.8 v1(104.7,124.52)
CAM_FRSYNC4: length 93.7
  TOP w0.107: v1(54.71,127.48) 55.1,127.09 J1.G7 ; J14.96 v1(117.5,172.72)
  IN1 w0.124: v1(54.71,127.48) 54.48,127.71 54.48,130.05 54.84,130.4 54.84,134.93 56.39,136.48 61.84,136.48 68.53,143.17 92,143.17 109.7,160.87 111.19,160.87 111.19,160.87 112.55,160.87 114.75,160.87 117.03,163.16 117.03,172.25 v1(117.5,172.72)
CAM_INT1: length 52.8
  TOP w0.107: J14.117 123,163.64 v1(123.57,163.07) ; J1.E61 v1(106.5,124.52)
  IN3 w0.124: v1(106.5,124.52) 106.6,124.62 106.6,126.49 106.05,127.05 106.05,128.6 107.45,130.01 107.45,131.24 107.85,131.65 107.85,137.65 108.56,138.35 108.56,146.74 109.44,147.62 109.44,150.67 110.52,151.74 110.52,154.33 117.25,161.06 119.53,161.06 121.54,163.07 v1(123.57,163.07)
  BOTTOM w0.107: v1(106.5,124.52) 107.06,125.08 TP10.1
CAM_INT2: length 60.9
  TOP w0.107: J14.106 v1(120,173.23) ; J1.D62 v1(107.6,123.02)
  IN3 w0.124: v1(120,173.23) 120,172.3 117.88,170.18 117.88,165.43 116.87,164.41 116.87,161.04 110.26,154.44 110.26,151.84 109.19,150.77 109.19,147.72 108.31,146.84 108.31,138.46 107.6,137.75 107.6,131.75 107.2,131.35 107.2,130.11 105.79,128.7 105.79,126.87 106.3,126.36 106.3,125.48 105.98,125.15 105.98,124.3 107.26,123.02 v1(107.6,123.02)
  BOTTOM w0.107: TP9.1 107.6,123.35 v1(107.6,123.02)
CAM_INT3: length 54.8
  TOP w0.107: J14.103 119.5,154.17 113.54,148.21 v1(108.58,148.21) ; J1.F60 v1(105.8,126.02)
  IN1 w0.124: v1(108.58,148.21) 108.2,148.21 105.03,145.03 105.03,139.72 102.36,137.06 102.36,131.72 101.52,130.88 101.52,128.46 101.98,127.99 101.98,127.38 102.61,126.75 105.41,126.75 105.8,126.36 v1(105.8,126.02)
  BOTTOM w0.107: v1(105.8,126.02) 105.79,126.01 TP8.1
CAM_INT4: length 58.9
  TOP w0.107: J1.D60 v1(105.8,123.02) ; J14.104 v1(119.5,172.72)
  IN3 w0.124: v1(119.5,172.72) 119.5,172.15 117.63,170.28 117.63,165.53 116.61,164.52 116.61,161.14 107.94,152.46 107.94,138.44 107.35,137.85 107.35,131.85 106.95,131.45 106.95,130.21 105.38,128.65 105.38,124.23 105.8,123.82 v1(105.8,123.02)
  BOTTOM w0.107: v1(105.8,123.02) 106.43,123.64 TP7.1
CAM_PG: length 2
  TOP w0.203: U34.8 130.79,175.41 131.67,174.52 RB4.1
CAM_SPI_CS0: length 3
  TOP w0.107: TP53.1 122,162.99 J14.113
CAM_SPI_MISO: length 3
  TOP w0.107: TP55.1 122,173.56 J14.114
CAM_SPI_MOSI: length 3
  TOP w0.107: TP54.1 121.5,173.65 J14.112
CAM_SPI_SCK: length 3
  TOP w0.107: TP52.1 121.5,163.03 J14.111
CAM_TE_RSV: length 41.1
  TOP w0.107: RZU7.1 v1(97.16,140.08) ; v1(102.74,148.39) 107.49,148.39 107.95,148.85 113.54,148.85 119,154.3 J14.101
  IN1 w0.124: v1(97.16,140.08) 97.16,142.8 v1(102.74,148.39)
CAM_VDD_SYS_EN: length 94.7
  TOP w0.107: v1(123.57,163.7) 123.5,163.78 J14.119 ; J1.E10 v1(57.8,123.22)
  IN1 w0.124: v1(57.8,123.22) 58.19,123.61 58.19,124.84 57.94,125.09 57.56,125.09 55.52,127.13 55.52,132.69 56.06,133.22 56.06,134.01 57.67,135.63 62.25,135.63 68.94,142.32 92.35,142.32 110.05,160.01 115.1,160.01 116.24,161.15 121.01,161.15 v1(123.57,163.7)
CAM_VDDEN: length 5
  TOP w0.203: U34.9 132.15,176.28 132.45,175.98 CA13.1
  TOP w0.508: RZ2.2 R245.2 R756.2 134.1,175.98 CA13.1
CAN0_DIN: length 107.1
  TOP w0.107: U40.5 v1(34.36,178.31) ; J1.F58 v1(104,126.02)
  IN1 w0.124: v1(77.34,136.4) 93.8,136.4 98.81,131.39 98.81,129.67 100.58,127.89 100.58,127.41 101.72,126.28 101.72,125.64 102.01,125.35 103.33,125.35 v1(104,126.02)
  IN3 w0.124: v1(34.36,178.31) 34.36,177.8 35,177.16 40.72,177.16 46.82,171.07 61.27,171.07 67.12,165.22 67.12,151.03 76.53,141.62 76.53,136.78 76.92,136.4 v1(77.34,136.4)
CAN0_DOUT: length 112.2
  TOP w0.107: J1.D59 v1(104.9,123.02) ; U40.3 v1(31.82,178.44)
  IN1 w0.124: v1(77.85,135.89) 93.6,135.89 98.3,131.19 98.3,129.29 99.19,128.4 99.19,127.53 100.48,126.24 100.48,124.18 101.09,123.57 104.65,123.57 104.9,123.32 v1(104.9,123.02)
  IN3 w0.124: v1(77.85,135.89) 76.71,135.89 76.03,136.57 76.03,141.41 66.61,150.82 66.61,165.01 61.06,170.56 46.61,170.56 40.51,176.66 33.78,176.66 32,178.44 v1(31.82,178.44)
CAN_REF: length 2.1
  TOP w0.508: C163.2 30.55,191.15 U40.15
  vias: v1(38.35,192.02) v1(38.35,191.26) v1(39.12,192.02) v1(39.12,191.26)
CANH: length 31.4
  TOP w0.107: NMEA2000.5 35.33,195.35 30.58,195.35 28.88,193.65 24.4,193.65 D12.2 24.33,193.01 v1(25.04,193.01) ; R265.2 33.38,192.35 RZU1.2 33.32,192.35 C162.1 32.17,192.95 32.36,193.15 v1(32.72,193.15)
  IN1 w0.124: v1(32.72,193.15) 32.57,193.29 25.32,193.29 v1(25.04,193.01)
  BOTTOM w0.107: v1(32.72,193.15) FL2.4 29.44,193.15 R264.2
CANL: length 31.1
  TOP w0.107: v1(25.04,194.41) 24.33,194.41 D13.2 24.38,195.02 29.57,195.02 30.38,195.83 33.82,195.83 NMEA2000.4 ; R265.1 34.49,193.34 RZU2.2 35.52,192.33 C164.1 35.67,192.56 v1(35.12,193.12)
  IN1 w0.124: v1(35.12,193.12) 34.45,193.12 33.76,193.8 25.65,193.8 v1(25.04,194.41)
  BOTTOM w0.107: v1(25.04,194.41) 25.17,194.41 R267.1 ; FL2.3 35.15,193.15 v1(35.12,193.12)
CARRIER_POWER_ON: length 147.7
  TOP w0.107: v1(110.11,140.34) R24.1 109.63,139.67 109.36,139.94 U4.4 ; RZU26.1 88.39,93.19 89.15,93.95 89.15,97.38 89.43,97.66 89.43,101.47 90.04,102.08 RZ56.1 v1(92.38,102.84) ; RZ45.1 v1(120.04,102.46) ; RZ5.2 v1(126.9,156.08)
  IN3 w0.124: v1(120.04,102.46) 120.04,105.27 124.74,109.96 124.74,129.28 127.06,131.6 127.06,140.17 v1(127.38,140.49) 127.12,140.75 127.12,151.34 127.46,151.68 127.46,155.52 v1(126.9,156.08) 127.46,156.64 127.46,158.42 128.32,159.28 131.85,159.28 134.87,162.31 134.87,165.81 138.71,169.64 v1(138.71,174.12)
  BOTTOM w0.107: v1(92.38,102.84) 92.38,102.95 94.56,105.13 100.31,105.13 103.08,102.36 111.65,102.36 112.57,103.28 119.23,103.28 v1(120.04,102.46) ; RZ147.1 v1(138.71,174.12) ; v1(110.11,140.34) 110.64,140.87 124.82,140.87 125.2,140.49 RZ167.1 v1(127.38,140.49)
CARRIER_SHUTDOWN_N: length 7.6
  TOP w0.107: U11.2 109.21,154.79 109.37,154.64 111.09,154.64 111.78,155.32 Q5.D Q4.D 114.27,153.67 RB22.2
CASE1_GND:
  vias: v1(26.04,197.1) v1(26.04,196.47) v1(26.8,197.1) v1(26.8,196.47)
CCG4_LED: length 26.9
  TOP w0.254: v1(141.68,40.97) 141.02,41.63 RZ120.1 139.34,42.75 Z10.2 139.29,43.92 RZ115.2
  IN1 w0.254: v1(141.68,40.97) 142.27,40.39 148.91,40.39 155.65,33.64 155.65,31.01 156.31,30.35 AUTOPW1.1
CHIPENABLE: length 5
  TOP w0.107: U20.50 77.47,65.75 77.33,65.61 RZ90.1 RZU34.2
CLK-ISP0#: length 51.6
  TOP w0.107: v1(142.27,72.14) 142.42,72.3 U13.13
  IN1 w0.124: v1(139.73,62.36) 139.73,64.03 141.25,65.56 141.25,71.75 141.63,72.14 v1(142.27,72.14)
  BOTTOM w0.107: v1(139.73,62.36) 139.34,62.36 138.58,61.59 133.06,61.59 132.55,62.1 124.74,62.1 123.85,61.21 123.85,52.58 122.25,50.97 SW1.4 SW1.3 ; RZ203.2 141.71,72.14 v1(142.27,72.14) 142.67,72.14 R62.1 R61.2
CLKREQ_M2_KEY_B_N: length 2.4
  BOTTOM w0.107: NGFF1.52 147.88,188.42 147.7,188.59 R221.1
CODEC_INT: length 112.1
  TOP w0.107: J1.B8 56.28,119.44 v1(56.28,120.02) ; v1(59.44,143.64) 60.29,143.64 63.57,146.92 113.99,146.92 117.84,150.77 131.42,150.77 133.38,152.73 136.86,152.73 137.76,151.83 139.38,151.83 v1(140.08,151.13)
  IN3 w0.124: v1(56.28,120.02) 56.28,121.1 58.72,123.55 58.72,125.91 59.94,127.13 59.94,127.86 58.98,128.83 58.98,140.46 59.44,140.92 v1(59.44,143.64)
  BOTTOM w0.107: RZ156.1 v1(140.08,151.13)
COMR_A: length 45
  TOP w0.203: U66.32 98.29,81.64 98.6,81.33 99.26,81.33 99.71,80.89
  TOP w0.508: 99.71,80.89 100.23,80.37 100.23,79.73 100.65,79.31 C291.2 100.65,70.9 99.72,69.98 97.82,69.98 97.18,69.34 97.18,64.77 v1(95.53,63.12) ; v1(104.98,56.85) 104.88,56.74 v1(103.06,56.74) 100.94,56.74 v1(100.89,56.69) v1(98.6,56.69) 96.95,56.69 v1(96.9,56.74)
  IN1 w0.508: v1(96.9,56.74) 95.53,58.12 v1(95.53,63.12)
  BOTTOM w0.508: R505.2 v1(96.9,56.74) ; R507.2 102.62,56.3 v1(103.06,56.74) 103.63,56.17 R513.2 ; v1(104.98,56.85) 104.78,56.64 R514.2 ; R508.2 98.04,56.13 v1(98.6,56.69) R510.2 ; R506.2 100.33,56.13 v1(100.89,56.69) R511.2
CSI_0_CLK_N: length 56.5
  TOP w0.102: v1(91.11,158.32) 90.88,158.54 90.88,164.21 91,164.33 J14.9 ; J1.F42 89.8,125.36 89.93,125.49 89.93,125.85 v3(89.78,126)
  IN3 w0.109: v1(91.11,158.32) 90.88,158.54 90.88,158.8 90.62,159.05 90.04,159.05 89.51,158.53 89.51,154.1 arc(89.66,153.74) 90.03,153.58 91.72,153.58 arc(91.91,153.5) 91.99,153.31 91.99,152.91 arc(91.92,152.73) 91.75,152.66 89.8,152.66 arc(89.41,152.5) 89.26,152.12 89.26,151.76 arc(89.41,151.39) 89.79,151.23 91.74,151.23 arc(91.92,151.16) 91.99,150.98 91.99,150.57 arc(91.91,150.39) 91.73,150.31 89.79,150.31 arc(89.43,150.16) 89.28,149.8 89.28,146.89 86.84,144.46 86.84,134.57 86.14,133.87 86.14,132.63 85.98,132.47 85.98,131.36 86.31,131.03 86.31,129.53 86.14,129.36 86.14,128.58 88.03,126.69 89.8,126.69 89.92,126.56 89.92,126.13 v3(89.78,126)
CSI_0_CLK_P: length 56.5
  TOP w0.102: v3(90.32,126) 90.18,125.86 90.18,125.49 90.31,125.36 J1.F43 ; v1(90.4,158.32) 90.63,158.54 90.63,164.21 90.5,164.34 J14.7
  IN3 w0.109: v1(90.4,158.32) 90.63,158.54 90.63,158.69 90.52,158.8 90.14,158.8 89.76,158.42 89.76,157.53 89.91,157.39 89.91,157.06 89.76,156.92 89.76,156.59 89.91,156.45 89.91,156.12 89.76,155.98 89.76,155.65 89.91,155.51 89.91,155.18 89.76,155.04 89.76,154.1 arc(89.84,153.92) 90.03,153.84 91.72,153.84 arc(92.09,153.68) 92.25,153.31 92.25,152.91 arc(92.1,152.55) 91.75,152.41 89.8,152.41 arc(89.59,152.32) 89.51,152.12 89.51,151.76 arc(89.59,151.57) 89.79,151.49 91.74,151.49 arc(92.1,151.34) 92.25,150.98 92.25,150.57 arc(92.09,150.21) 91.73,150.06 89.79,150.06 arc(89.61,149.98) 89.53,149.8 89.53,149.23 89.68,149.08 89.68,148.76 89.53,148.61 89.53,148.29 89.68,148.14 89.68,147.82 89.53,147.67 89.53,146.79 87.1,144.35 87.1,136.75 87.24,136.61 87.24,136.28 87.1,136.14 87.1,135.82 87.24,135.67 87.24,135.35 87.1,135.2 87.1,134.47 86.39,133.76 86.39,132.52 86.23,132.36 86.23,131.46 86.56,131.13 86.56,129.4 86.39,129.23 86.39,128.68 88.14,126.94 89.9,126.94 90.18,126.66 90.18,126.13 v3(90.32,126)
CSI_0_D0_N: length 57.3
  TOP w0.102: v1(89.6,161.62) 89.38,161.85 89.38,164.23 89.5,164.35 J14.3 ; J1.E41 88.7,123.86 88.83,123.99 88.83,124.35 v3(88.68,124.5)
  IN3 w0.109: v3(88.68,124.5) 88.82,124.36 88.82,124.06 88.59,123.83 88.19,123.83 88.05,123.97 87.72,123.97 87.58,123.83 87.25,123.83 87.11,123.97 86.78,123.97 86.64,123.83 85.55,123.83 85.07,124.31 84.8,127.02 84.12,129.1 84.12,129.59 84.27,129.73 84.27,130.06 84.12,130.2 84.12,130.53 84.27,130.67 84.27,131 84.12,131.14 84.12,132.34 83.81,132.65 83.81,134.62 83.95,134.76 83.95,135.09 83.81,135.23 83.81,135.56 83.95,135.7 83.95,136.03 83.81,136.17 83.81,136.5 83.95,136.64 83.95,136.97 83.81,137.11 83.81,142.04 arc(83.93,142.32) 84.21,142.44 84.93,142.44 arc(85.33,142.6) 85.5,143 85.5,143.35 arc(85.35,143.72) 84.98,143.87 84.12,143.87 arc(83.9,143.96) 83.81,144.17 83.81,144.52 arc(83.89,144.71) 84.08,144.79 85,144.79 arc(85.35,144.94) 85.5,145.29 85.5,145.72 arc(85.35,146.07) 85,146.22 84.1,146.22 arc(83.9,146.3) 83.81,146.5 83.81,146.83 arc(83.9,147.05) 84.13,147.14 87.05,147.14 87.91,148.01 87.91,159 89.38,160.47 89.38,161.39 v1(89.6,161.62)
CSI_0_D0_P: length 57.2
  TOP w0.102: v1(88.89,161.62) 89.12,161.85 89.12,164.22 89,164.34 J14.1 ; J1.E42 89.25,123.86 89.08,124.03 89.08,124.36 v3(89.22,124.5)
  IN3 w0.109: v1(88.89,161.62) 89.12,161.39 89.12,160.58 87.66,159.11 87.66,148.11 86.94,147.4 84.13,147.4 arc(83.73,147.23) 83.56,146.83 83.56,146.5 arc(83.72,146.12) 84.1,145.97 85,145.97 arc(85.17,145.89) 85.24,145.72 85.24,145.29 arc(85.17,145.12) 85,145.04 84.08,145.04 arc(83.71,144.89) 83.56,144.52 83.56,144.17 arc(83.72,143.78) 84.12,143.61 84.98,143.61 arc(85.17,143.54) 85.24,143.35 85.24,143 arc(85.15,142.78) 84.93,142.69 84.21,142.69 arc(83.75,142.5) 83.56,142.04 83.56,132.55 83.87,132.24 83.87,129.06 84.55,126.97 84.82,124.19 85.45,123.57 88.69,123.57 89.08,123.96 89.08,124.36 v3(89.22,124.5)
CSI_0_D1_N: length 57.2
  TOP w0.102: v3(85.98,124.5) 86.13,124.35 86.13,123.99 86,123.86 J1.E38 ; J14.15 92.5,164.41 92.35,164.26 92.35,163.34 91.97,162.96 91.97,159.78 v1(92.18,159.58)
  IN3 w0.109: v3(85.98,124.5) 86.08,124.59 86.08,127.47 84.82,128.73 84.82,129.67 85.35,130.2 85.35,130.71 84.73,131.33 84.73,132.46 84.33,132.87 84.33,134.06 arc(84.55,134.6) 85.09,134.82 85.7,134.82 arc(85.88,134.9) 85.95,135.08 85.95,135.52 arc(85.89,135.68) 85.72,135.75 84.99,135.75 arc(84.63,135.9) 84.48,136.26 84.48,136.65 arc(84.63,137.02) 85,137.18 85.8,137.18 arc(85.96,137.24) 86.03,137.4 86.03,137.82 arc(85.95,138.02) 85.75,138.1 84.86,138.1 arc(84.5,138.25) 84.35,138.61 84.35,139.04 arc(84.5,139.38) 84.84,139.53 85.75,139.53 arc(85.95,139.61) 86.03,139.81 86.03,140.2 arc(85.96,140.37) 85.78,140.45 84.87,140.45 arc(84.51,140.6) 84.35,140.97 84.35,141.35 arc(84.51,141.72) 84.89,141.88 85.6,141.88 arc(85.9,142.01) 86.03,142.31 86.03,144.94 88.44,147.35 88.44,158.75 90.04,160.35 91.61,160.35 91.95,160.01 91.95,159.81 v1(92.18,159.58)
CSI_0_D1_P: length 57.2
  TOP w0.102: v1(91.47,159.58) 91.72,159.83 91.72,163.07 92.1,163.44 92.1,164.26 92,164.36 J14.13 ; v3(86.52,124.5) 86.38,124.36 86.38,123.99 86.51,123.86 J1.E39
  IN3 w0.109: v3(86.52,124.5) 86.33,124.68 86.33,127.57 85.07,128.84 85.07,129.56 85.61,130.1 85.61,130.82 84.99,131.44 84.99,132.57 84.58,132.97 84.58,134.06 arc(84.73,134.42) 85.09,134.57 85.7,134.57 arc(86.06,134.72) 86.21,135.08 86.21,135.52 arc(86.07,135.86) 85.72,136 84.99,136 arc(84.81,136.07) 84.73,136.26 84.73,136.65 arc(84.81,136.84) 85,136.92 85.8,136.92 arc(86.14,137.06) 86.28,137.4 86.28,137.82 arc(86.13,138.2) 85.75,138.35 84.86,138.35 arc(84.68,138.43) 84.61,138.61 84.61,139.04 arc(84.68,139.2) 84.84,139.27 85.75,139.27 arc(86.13,139.43) 86.28,139.81 86.28,140.2 arc(86.14,140.55) 85.78,140.7 84.87,140.7 arc(84.69,140.78) 84.61,140.97 84.61,141.35 arc(84.69,141.54) 84.89,141.63 85.6,141.63 arc(86.08,141.83) 86.28,142.31 86.28,144.83 86.46,145.01 86.67,145.01 86.9,145.24 86.9,145.45 87.13,145.68 87.33,145.68 87.56,145.91 87.56,146.11 87.79,146.34 88,146.34 88.23,146.57 88.23,146.77 88.7,147.24 88.7,155.37 88.84,155.51 88.84,155.84 88.7,155.98 88.7,156.31 88.84,156.45 88.84,156.78 88.7,156.92 88.7,157.25 88.84,157.39 88.84,157.72 88.7,157.86 88.7,158.65 89.12,159.07 89.32,159.07 89.55,159.3 89.55,159.5 90.14,160.1 91.5,160.1 91.69,159.9 91.69,159.81 v1(91.47,159.58)
CSI_1_CLK_N: length 57.4
  TOP w0.102: v3(89.78,128.99) 89.93,128.85 89.93,128.49 89.8,128.36 J1.H42 ; v1(91.1,174.21) 90.88,173.98 90.88,172.27 91,172.15 J14.10
  IN3 w0.109: v1(91.1,174.21) 90.88,174.44 90.88,174.54 90.98,174.65 91.49,174.65 92.3,173.84 93.44,173.84 93.6,173.68 93.6,173.35 93.46,173.21 93.46,172.88 93.6,172.74 93.6,172.31 93.21,171.92 93,171.92 92.77,171.69 92.77,171.49 92.13,170.84 92.13,169.83 91.98,169.68 91.98,169.36 92.13,169.21 92.13,168.89 91.98,168.74 91.98,168.42 92.13,168.27 92.13,167.95 91.98,167.8 91.98,167.48 92.13,167.33 92.13,163.14 92.53,162.74 92.53,162.54 92.76,162.3 92.96,162.3 93.2,162.07 93.2,161.87 93.43,161.64 93.63,161.64 94.3,160.97 94.3,148.46 89.3,143.45 89.3,132.5 89.47,132.33 89.47,131.5 90.15,130.82 90.15,130.32 89.94,130.1 89.94,129.15 v3(89.78,128.99)
CSI_1_CLK_P: length 57.4
  TOP w0.102: v1(90.39,174.21) 90.62,173.98 90.62,172.29 90.5,172.17 J14.8 ; v3(90.32,128.99) 90.18,128.86 90.18,128.51 90.33,128.36 J1.H43
  IN3 w0.109: v3(90.32,128.99) 90.19,129.12 90.19,130 90.41,130.21 90.41,130.92 89.72,131.61 89.72,132.44 89.55,132.61 89.55,143.35 94.55,148.35 94.55,161.07 92.38,163.25 92.38,170.73 93.85,172.21 93.85,173.79 93.55,174.09 92.4,174.09 91.59,174.9 90.88,174.9 90.62,174.65 90.62,174.44 v1(90.39,174.21)
CSI_1_D0_N: length 57.1
  TOP w0.102: v1(89.6,173.19) 89.38,172.96 89.38,172.27 89.5,172.15 J14.4 ; J1.G42 89.2,126.86 89.08,126.97 89.08,127.36 v3(89.22,127.5)
  IN3 w0.109: v3(89.22,127.5) 89.06,127.65 89.06,128.28 88.66,128.68 88.66,129.37 87.5,130.52 87.5,131.45 87.31,131.64 87.31,133.57 88.01,134.26 88.01,144.09 93.01,149.1 93.01,160.03 89.94,163.11 88.71,163.11 arc(88.52,163.18) 88.44,163.37 88.44,163.75 arc(88.52,163.95) 88.72,164.03 89,164.03 arc(89.36,164.18) 89.51,164.54 89.51,164.9 arc(89.35,165.29) 88.95,165.46 88.69,165.46 arc(88.46,165.55) 88.37,165.79 88.37,166.13 arc(88.44,166.31) 88.62,166.38 88.87,166.38 arc(89.32,166.57) 89.51,167.01 89.51,170.26 89.38,170.39 89.38,172.96 v1(89.6,173.19)
CSI_1_D0_P: length 57
  TOP w0.102: J1.G41 88.7,126.86 88.83,126.99 88.83,127.35 v3(88.68,127.5) ; J14.2 89,172.16 89.12,172.28 89.12,172.96 v1(88.89,173.19)
  IN3 w0.109: v3(88.68,127.5) 88.81,127.62 88.81,128.18 88.4,128.58 88.4,129.26 87.25,130.42 87.25,131.34 87.06,131.53 87.06,133.67 87.76,134.37 87.76,144.2 92.76,149.2 92.76,159.93 89.83,162.85 88.71,162.85 arc(88.34,163) 88.19,163.37 88.19,163.75 arc(88.35,164.13) 88.72,164.28 89,164.28 arc(89.18,164.36) 89.26,164.54 89.26,164.9 arc(89.17,165.11) 88.95,165.2 88.69,165.2 arc(88.28,165.37) 88.11,165.79 88.11,166.13 arc(88.26,166.48) 88.62,166.63 88.87,166.63 arc(89.14,166.75) 89.26,167.01 89.26,170.15 89.12,170.28 89.12,172.96 v1(88.89,173.19)
CSI_1_D1_N: length 56.2
  TOP w0.102: v1(92.6,173.19) 92.38,172.96 92.38,172.27 92.5,172.15 J14.16 ; J1.J42 89.21,129.86 89.08,129.99 89.08,130.36 v3(89.22,130.5)
  IN3 w0.109: v1(92.6,173.19) 92.38,172.96 92.38,172.08 91.87,171.58 90.58,171.58 arc(90.37,171.49) 90.28,171.28 90.28,170.89 arc(90.34,170.73) 90.5,170.67 90.96,170.67 arc(91.3,170.53) 91.44,170.18 91.44,169.75 arc(91.29,169.39) 90.93,169.24 90.53,169.24 arc(90.35,169.16) 90.28,168.99 90.28,168.56 arc(90.35,168.39) 90.53,168.32 90.96,168.32 arc(91.3,168.17) 91.44,167.83 91.44,167.36 arc(91.3,167.02) 90.96,166.89 90.49,166.89 arc(90.34,166.82) 90.28,166.67 90.28,166.22 arc(90.35,166.04) 90.53,165.96 91.16,165.96 arc(91.48,165.83) 91.61,165.51 91.61,165.01 arc(91.47,164.67) 91.14,164.53 91.03,164.53 arc(90.89,164.47) 90.83,164.33 90.83,163.3 93.78,160.35 93.78,148.73 88.78,143.73 88.78,132.61 88.58,132.41 88.58,131.47 89.06,130.99 89.06,130.65 v3(89.22,130.5)
CSI_1_D1_P: length 56.2
  TOP w0.102: J1.J41 88.7,129.86 88.83,129.99 88.83,130.35 v3(88.68,130.5) ; v1(91.89,173.19) 92.12,172.96 92.12,172.29 92,172.17 J14.14
  IN3 w0.109: v1(91.89,173.19) 92.12,172.96 92.12,172.19 91.77,171.83 90.58,171.83 arc(90.19,171.67) 90.03,171.28 90.03,170.89 arc(90.16,170.55) 90.5,170.41 90.96,170.41 arc(91.12,170.35) 91.19,170.18 91.19,169.75 arc(91.11,169.57) 90.93,169.49 90.53,169.49 arc(90.17,169.34) 90.03,168.99 90.03,168.56 arc(90.17,168.21) 90.53,168.06 90.96,168.06 arc(91.12,167.99) 91.19,167.83 91.19,167.36 arc(91.12,167.2) 90.96,167.14 90.49,167.14 arc(90.16,167) 90.03,166.67 90.03,166.22 arc(90.17,165.86) 90.53,165.71 91.16,165.71 arc(91.3,165.65) 91.36,165.51 91.36,165.01 arc(91.29,164.85) 91.14,164.79 91.03,164.79 arc(90.71,164.65) 90.58,164.33 90.58,163.2 93.53,160.24 93.53,148.84 88.53,143.83 88.53,132.72 88.32,132.51 88.32,131.36 88.81,130.88 88.81,130.62 v3(88.68,130.5)
CSI_2_CLK_N: length 66.4
  TOP w0.102: J14.27 95.5,164.37 95.38,164.25 95.38,162.31 v1(95.61,162.08) ; v3(89.78,120) 89.93,119.85 89.93,119.49 89.8,119.36 J1.B42
  BOTTOM w0.102: v1(95.61,162.08) 95.38,162.31 95.38,162.56 95.13,162.81 94.56,162.81 93.8,162.06 93.8,153.64 arc(93.71,153.41) 93.47,153.31 91.87,153.31 arc(91.51,153.16) 91.36,152.8 91.36,152.42 arc(91.52,152.05) 91.9,151.89 93.52,151.89 arc(93.72,151.81) 93.8,151.61 93.8,151.21 arc(93.73,151.04) 93.57,150.98 91.87,150.98 arc(91.51,150.83) 91.36,150.47 91.36,150.06 arc(91.51,149.7) 91.87,149.55 93.34,149.55 arc(93.54,149.47) 93.62,149.27 93.62,148.97 arc(93.53,148.74) 93.29,148.64 92.33,148.64 arc(91.83,148.43) 91.62,147.93 91.62,146.86 84.35,139.59 84.35,132.87 84.84,132.38 84.84,131.43 85.39,130.87 85.39,130.22 84.86,129.69 84.86,128.46 85.45,127.88 85.45,127.15 84.81,126.51 84.81,124.24 85.19,123.86 85.83,123.86 86.23,123.46 86.23,122.45 87.94,120.74 89.49,120.74 89.92,120.31 89.92,120.13 v3(89.78,120)
CSI_2_CLK_P: length 66.4
  TOP w0.102: J14.25 95,164.37 95.12,164.25 95.12,162.31 v1(94.89,162.08) ; v3(90.32,120) 90.18,119.86 90.18,119.49 90.31,119.36 J1.B43
  BOTTOM w0.102: v1(94.89,162.08) 95.12,162.31 95.12,162.46 95.02,162.56 94.67,162.56 94.06,161.95 94.06,160.93 94.21,160.78 94.21,160.48 94.06,160.33 94.06,160.02 94.21,159.87 94.21,159.57 94.06,159.42 94.06,159.11 94.21,158.96 94.21,158.66 94.06,158.51 94.06,153.64 arc(93.89,153.23) 93.47,153.06 91.87,153.06 arc(91.69,152.98) 91.62,152.8 91.62,152.42 arc(91.7,152.23) 91.9,152.14 93.52,152.14 arc(93.9,151.99) 94.06,151.61 94.06,151.21 arc(93.91,150.86) 93.57,150.72 91.87,150.72 arc(91.69,150.65) 91.62,150.47 91.62,150.06 arc(91.69,149.88) 91.87,149.81 93.34,149.81 arc(93.72,149.65) 93.88,149.27 93.88,148.97 arc(93.71,148.56) 93.29,148.39 92.33,148.39 arc(92.01,148.25) 91.87,147.93 91.87,146.75 84.61,139.49 84.61,136.56 84.76,136.41 84.76,136.11 84.61,135.96 84.61,135.65 84.76,135.5 84.76,135.2 84.61,135.05 84.61,134.74 84.76,134.59 84.76,134.29 84.61,134.14 84.61,132.97 85.09,132.49 85.09,131.54 85.65,130.98 85.65,130.11 85.12,129.58 85.12,128.56 85.7,127.98 85.7,127.04 85.06,126.41 85.06,125.55 85.21,125.4 85.21,125.09 85.06,124.95 85.06,124.34 85.29,124.11 85.94,124.11 86.49,123.56 86.49,122.56 88.05,121 89.59,121 90.18,120.41 90.18,120.13 v3(90.32,120)
CSI_2_D0_N: length 66
  TOP w0.102: J1.A42 89.21,117.86 89.08,117.99 89.08,118.36 v3(89.22,118.5) ; v1(94.1,163.3) 93.88,163.53 93.88,164.23 94,164.36 J14.21
  BOTTOM w0.102: v1(94.1,163.3) 93.88,163.07 93.88,162.86 93.27,162.26 93.27,154.31 92.86,153.9 89.33,153.9 arc(89.17,153.83) 89.1,153.67 89.1,153.19 arc(89.16,153.04) 89.31,152.98 90.32,152.98 arc(90.68,152.83) 90.83,152.48 90.83,152.07 arc(90.68,151.71) 90.32,151.56 89.33,151.56 arc(89.17,151.49) 89.1,151.33 89.1,150.9 arc(89.18,150.72) 89.36,150.65 90.32,150.65 arc(90.68,150.5) 90.83,150.14 90.83,149.71 arc(90.69,149.36) 90.35,149.22 89.35,149.22 arc(89.18,149.15) 89.1,148.97 89.1,148.56 arc(89.18,148.38) 89.36,148.31 90.35,148.31 arc(90.69,148.17) 90.83,147.83 90.83,147.4 arc(90.68,147.04) 90.32,146.89 89.36,146.89 arc(89.18,146.81) 89.1,146.63 89.1,145.06 83.74,139.7 83.74,132.76 84.3,132.2 84.3,124.03 85.14,123.19 85.14,122.32 86.61,120.84 86.61,119.84 87.16,119.29 88.77,119.29 89.08,118.99 89.08,118.63 v3(89.22,118.5)
CSI_2_D0_P: length 66
  TOP w0.102: J1.A41 88.7,117.86 88.83,117.99 88.83,118.35 v3(88.68,118.5) ; v1(93.39,163.3) 93.62,163.53 93.62,164.23 93.5,164.36 J14.19
  BOTTOM w0.102: v3(88.68,118.5) 88.82,118.63 88.82,118.88 88.67,119.04 87.06,119.04 86.36,119.74 86.36,120.74 84.89,122.21 84.89,123.08 84.05,123.92 84.05,132.09 83.49,132.65 83.49,139.81 88.85,145.16 88.85,146.63 arc(89,146.99) 89.36,147.14 90.32,147.14 arc(90.5,147.21) 90.58,147.4 90.58,147.83 arc(90.51,147.99) 90.35,148.05 89.36,148.05 arc(89,148.2) 88.85,148.56 88.85,148.97 arc(89,149.33) 89.35,149.48 90.35,149.48 arc(90.51,149.54) 90.58,149.71 90.58,150.14 arc(90.5,150.32) 90.32,150.39 89.36,150.39 arc(89,150.54) 88.85,150.9 88.85,151.33 arc(88.99,151.67) 89.33,151.81 90.32,151.81 arc(90.5,151.89) 90.58,152.07 90.58,152.48 arc(90.5,152.65) 90.32,152.73 89.31,152.73 arc(88.98,152.86) 88.85,153.19 88.85,153.67 arc(88.99,154.01) 89.33,154.15 92.75,154.15 93.01,154.41 93.01,162.36 93.62,162.97 93.62,163.07 v1(93.39,163.3)
CSI_2_D1_N: length 65.1
  TOP w0.102: J1.C41 88.7,120.86 88.83,120.99 88.83,121.35 v3(88.68,121.5) ; J14.33 97,164.36 96.88,164.24 96.88,160.43 v1(97.1,160.2)
  BOTTOM w0.102: v1(97.1,160.2) 96.88,160.43 96.88,160.66 96.63,160.91 95.45,160.91 94.95,160.41 94.95,149.07 87.93,142.06 87.93,141.49 arc(87.85,141.29) 87.66,141.21 87.33,141.21 arc(86.97,141.06) 86.82,140.7 86.82,140.32 arc(86.97,139.94) 87.35,139.79 87.71,139.79 arc(87.87,139.72) 87.93,139.56 87.93,139.1 arc(87.87,138.94) 87.71,138.87 85.66,138.87 arc(85.31,138.73) 85.17,138.38 85.17,137.97 arc(85.32,137.6) 85.69,137.45 87.69,137.45 arc(87.86,137.38) 87.93,137.21 87.93,136.79 arc(87.86,136.61) 87.68,136.54 85.79,136.54 arc(85.42,136.38) 85.27,136.02 85.27,135.65 arc(85.42,135.27) 85.8,135.11 87.69,135.11 arc(87.86,135.04) 87.93,134.87 87.93,134.45 arc(87.86,134.27) 87.68,134.2 86.7,134.2 arc(86.33,134.05) 86.18,133.68 86.18,132.84 85.98,132.64 85.98,131.38 86.18,131.18 86.18,128.59 86.26,128.51 86.26,125.86 87.5,124.61 87.5,123.94 87.75,123.69 88.34,123.69 88.52,123.51 88.52,122.57 88.82,122.26 88.82,121.63 v3(88.68,121.5)
CSI_2_D1_P: length 65.1
  TOP w0.102: J14.31 96.5,164.36 96.62,164.24 96.62,160.43 v1(96.39,160.2) ; v3(89.22,121.5) 89.08,121.36 89.08,120.99 89.21,120.86 J1.C42
  BOTTOM w0.102: v1(96.39,160.2) 96.62,160.43 96.62,160.55 96.52,160.66 95.55,160.66 95.2,160.3 95.2,159.46 95.35,159.31 95.35,159 95.2,158.85 95.2,158.55 95.35,158.4 95.35,158.09 95.2,157.94 95.2,157.64 95.35,157.49 95.35,157.19 95.2,157.04 95.2,148.96 94.67,148.43 94.67,148.22 94.45,148 94.24,148 94.02,147.79 94.02,147.58 93.81,147.36 93.6,147.36 93.38,147.15 93.38,146.93 93.17,146.72 92.95,146.72 88.19,141.95 88.19,141.49 arc(88.03,141.11) 87.66,140.96 87.33,140.96 arc(87.15,140.88) 87.07,140.7 87.07,140.32 arc(87.15,140.12) 87.35,140.04 87.71,140.04 arc(88.05,139.9) 88.19,139.56 88.19,139.1 arc(88.05,138.76) 87.71,138.62 85.66,138.62 arc(85.49,138.55) 85.42,138.38 85.42,137.97 arc(85.5,137.78) 85.69,137.71 87.69,137.71 arc(88.04,137.56) 88.19,137.21 88.19,136.79 arc(88.04,136.43) 87.68,136.28 85.79,136.28 arc(85.6,136.21) 85.52,136.02 85.52,135.65 arc(85.6,135.45) 85.8,135.37 87.69,135.37 arc(88.04,135.22) 88.19,134.87 88.19,134.45 arc(88.04,134.09) 87.68,133.95 86.7,133.95 arc(86.51,133.87) 86.44,133.68 86.44,132.74 86.23,132.53 86.23,131.49 86.44,131.29 86.44,130.38 86.59,130.23 86.59,129.92 86.44,129.77 86.44,128.69 86.51,128.62 86.51,125.96 87.76,124.72 87.76,124.04 87.86,123.94 88.44,123.94 88.77,123.61 88.77,122.67 89.08,122.37 89.08,121.63 v3(89.22,121.5)
CSI_3_CLK_N: length 66.9
  TOP w0.102: v1(95.96,175.13) 95.73,174.9 95.73,173.61 95.38,173.25 95.38,172.27 95.5,172.15 J14.28 ; v3(92.48,126) 92.63,125.85 92.63,125.49 92.5,125.36 J1.F45
  BOTTOM w0.102: v3(92.48,126) 92.62,126.13 92.62,126.65 92.89,126.92 92.89,127.73 93.93,128.77 93.93,129.15 93.42,129.66 93.42,134.21 arc(93.35,134.37) 93.19,134.44 92.81,134.44 arc(92.47,134.58) 92.33,134.92 92.33,135.38 arc(92.47,135.72) 92.81,135.86 93.19,135.86 arc(93.35,135.93) 93.42,136.09 93.42,136.55 arc(93.35,136.71) 93.19,136.78 92.81,136.78 arc(92.47,136.92) 92.33,137.26 92.33,137.69 arc(92.48,138.05) 92.84,138.2 93.19,138.2 arc(93.35,138.27) 93.42,138.43 93.42,138.89 arc(93.35,139.05) 93.19,139.12 92.84,139.12 arc(92.48,139.26) 92.33,139.62 92.33,140.03 arc(92.48,140.39) 92.84,140.54 93.17,140.54 arc(93.35,140.61) 93.42,140.79 93.42,143.59 97.38,147.55 97.38,154.22 99.75,156.58 99.75,161.71 99.6,161.86 99.6,162.16 99.75,162.31 99.75,162.62 99.6,162.77 99.6,163.07 99.75,163.22 99.75,163.53 99.6,163.68 99.6,163.98 99.75,164.13 99.75,164.92 97.56,167.1 97.56,169.24 98.02,169.7 98.02,170.14 97.87,170.29 97.87,170.6 98.02,170.75 98.02,171.05 97.87,171.2 97.87,171.51 98.02,171.66 98.02,171.96 97.87,172.11 97.87,172.42 98.02,172.57 98.02,173.17 97.57,173.62 97.36,173.62 97.14,173.84 97.14,174.05 96.93,174.27 96.93,175.38 96.72,175.59 95.83,175.59 95.73,175.48 95.73,175.35 v1(95.96,175.13)
CSI_3_CLK_P: length 66.9
  TOP w0.102: v1(95.25,175.13) 95.48,174.9 95.48,173.71 95.12,173.35 95.12,172.26 95,172.14 J14.26 ; v3(93.02,126) 92.88,125.86 92.88,125.51 93.04,125.36 J1.F46
  BOTTOM w0.102: v3(93.02,126) 92.88,126.13 92.88,126.55 93.14,126.81 93.14,127.62 94.19,128.67 94.19,129.26 93.68,129.77 93.68,134.21 arc(93.53,134.55) 93.19,134.7 92.81,134.7 arc(92.65,134.76) 92.58,134.92 92.58,135.38 arc(92.65,135.54) 92.81,135.61 93.19,135.61 arc(93.53,135.75) 93.68,136.09 93.68,136.55 arc(93.53,136.89) 93.19,137.03 92.81,137.03 arc(92.65,137.1) 92.58,137.26 92.58,137.69 arc(92.66,137.87) 92.84,137.95 93.19,137.95 arc(93.53,138.09) 93.68,138.43 93.68,138.89 arc(93.53,139.23) 93.19,139.37 92.84,139.37 arc(92.66,139.44) 92.58,139.62 92.58,140.03 arc(92.66,140.21) 92.84,140.28 93.17,140.28 arc(93.53,140.43) 93.68,140.79 93.68,143.48 97.64,147.45 97.64,154.11 100,156.48 100,165.02 97.82,167.21 97.82,169.14 98.27,169.6 98.27,173.28 97.18,174.37 97.18,175.49 96.83,175.84 95.73,175.84 95.48,175.59 95.48,175.35 v1(95.25,175.13)
CSI_3_D0_N: length 67.2
  TOP w0.102: J14.22 94,172.12 93.85,172.27 93.85,173.25 93.45,173.66 93.45,174.93 v1(93.68,175.16) ; J1.E44 91.4,123.86 91.53,123.99 91.53,124.35 v3(91.38,124.5)
  BOTTOM w0.102: v3(91.38,124.5) 91.52,124.63 91.52,124.93 91.29,125.16 91.29,126.3 91.03,126.56 90.57,126.56 90.2,126.94 90.2,127.98 90.06,128.11 88.87,128.11 88.52,128.46 88.52,129.07 87.52,130.08 87.52,130.85 88.27,131.6 88.27,132.57 88.7,133 88.7,141.45 95.71,148.46 95.71,154.94 97.89,157.13 97.89,161.46 96.7,162.66 96.7,163.61 96.55,163.76 96.55,164.06 96.7,164.21 96.7,164.52 96.55,164.67 96.55,164.97 96.7,165.12 96.7,165.63 96.17,166.15 95.96,166.15 95.75,166.37 95.75,166.58 95.28,167.05 95.28,170.07 95.13,170.22 95.13,170.52 95.28,170.67 95.28,170.98 95.13,171.12 95.13,171.43 95.28,171.58 95.28,171.88 95.13,172.03 95.13,172.34 95.28,172.49 95.28,173 95.03,173.24 94.82,173.24 94.6,173.46 94.6,173.67 94.36,173.91 94.36,175.54 94.18,175.72 93.6,175.72 93.45,175.56 93.45,175.39 v1(93.68,175.16)
CSI_3_D0_P: length 67.2
  TOP w0.102: v1(92.96,175.16) 93.19,174.93 93.19,173.55 93.6,173.15 93.6,172.27 93.6,172.27 93.57,172.27 93.5,172.19 J14.20 ; J1.E45 91.9,123.86 91.78,123.98 91.78,124.36 v3(91.92,124.5)
  BOTTOM w0.102: v3(91.92,124.5) 91.78,124.63 91.78,125.03 91.54,125.27 91.54,126.41 91.14,126.81 90.68,126.81 90.45,127.04 90.45,128.08 90.17,128.36 88.98,128.36 88.77,128.56 88.77,129.18 87.77,130.18 87.77,130.75 88.52,131.5 88.52,132.46 88.95,132.89 88.95,141.35 95.96,148.36 95.96,154.84 98.15,157.02 98.15,161.57 96.95,162.76 96.95,165.74 95.53,167.16 95.53,173.1 94.61,174.02 94.61,175.64 94.28,175.97 93.5,175.97 93.19,175.67 93.19,175.39 v1(92.96,175.16)
CSI_3_D1_N: length 66
  TOP w0.102: v1(97.1,173.19) 96.88,172.96 96.88,172.27 97,172.15 J14.34 ; v3(91.91,127.43) 91.78,127.3 91.78,126.99 91.91,126.86 J1.G45
  BOTTOM w0.102: v3(91.91,127.43) 91.89,127.43 91.77,127.55 91.77,128.23 91.52,128.49 91.52,129.23 90.44,130.3 90.44,130.96 89.74,131.67 89.74,133.88 arc(89.82,134.07) 90,134.15 91.32,134.15 arc(91.68,134.29) 91.82,134.65 91.82,135.08 arc(91.68,135.43) 91.33,135.57 90.01,135.57 arc(89.82,135.65) 89.74,135.84 89.74,136.21 arc(89.82,136.4) 90.02,136.49 91.35,136.49 arc(91.68,136.62) 91.82,136.96 91.82,137.43 arc(91.68,137.77) 91.34,137.91 89.98,137.91 arc(89.81,137.98) 89.74,138.15 89.74,138.58 arc(89.81,138.75) 89.98,138.82 91.34,138.82 arc(91.68,138.96) 91.82,139.31 91.82,139.75 arc(91.68,140.1) 91.33,140.24 90.01,140.24 arc(89.82,140.32) 89.74,140.51 89.74,140.97 arc(89.8,141.1) 89.93,141.16 91.26,141.16 arc(91.66,141.32) 91.82,141.72 91.82,143.05 96.79,148.02 96.79,154.47 98.97,156.65 98.97,162.22 98.37,162.81 98.37,165.51 96.88,167.01 96.88,172.96 v1(97.1,173.19)
CSI_3_D1_P: length 66
  TOP w0.102: J14.32 96.5,172.11 96.62,172.24 96.62,172.96 v1(96.39,173.19) ; J1.G44 91.4,126.86 91.53,126.99 91.53,127.29 v3(91.38,127.43)
  BOTTOM w0.102: v1(96.39,173.19) 96.62,172.96 96.62,166.9 98.12,165.4 98.12,162.71 98.72,162.11 98.72,156.76 96.53,154.57 96.53,148.12 91.57,143.15 91.57,141.72 arc(91.48,141.5) 91.26,141.41 89.93,141.41 arc(89.62,141.28) 89.48,140.97 89.48,140.51 arc(89.64,140.14) 90.01,139.99 91.33,139.99 arc(91.5,139.92) 91.57,139.75 91.57,139.31 arc(91.5,139.14) 91.34,139.08 89.98,139.08 arc(89.63,138.93) 89.48,138.58 89.48,138.15 arc(89.63,137.8) 89.98,137.65 91.34,137.65 arc(91.5,137.59) 91.57,137.43 91.57,136.96 arc(91.5,136.8) 91.35,136.74 90.02,136.74 arc(89.64,136.58) 89.48,136.21 89.48,135.84 arc(89.64,135.47) 90.01,135.32 91.33,135.32 arc(91.5,135.25) 91.57,135.08 91.57,134.65 arc(91.5,134.47) 91.32,134.4 90,134.4 arc(89.64,134.25) 89.48,133.88 89.48,131.56 90.19,130.86 90.19,130.19 91.26,129.12 91.26,128.38 91.52,128.13 91.52,127.55 91.4,127.43 v3(91.38,127.43)
CSI_4_CLK_N: length 57.8
  TOP w0.102: v3(95.72,126) 95.58,125.86 95.58,125.48 95.7,125.36 J1.F49 ; J14.45 100,164.36 99.88,164.24 99.88,162.87 100.03,162.71 101.12,162.71 101.37,162.46 101.37,161.85 v1(101.6,161.62)
  IN3 w0.109: v3(95.72,126) 95.56,126.15 95.56,126.77 95.78,126.99 95.78,127.84 95.23,128.39 95.23,129.53 94.92,129.84 94.92,131 95.53,131.61 95.53,140.49 98.45,143.41 102.13,143.41 arc(102.49,143.56) 102.64,143.92 102.64,144.35 arc(102.5,144.69) 102.15,144.84 100.89,144.84 arc(100.71,144.91) 100.63,145.09 100.63,145.52 arc(100.71,145.69) 100.88,145.76 102.12,145.76 arc(102.49,145.91) 102.64,146.28 102.64,146.69 arc(102.49,147.04) 102.14,147.19 100.94,147.19 arc(100.78,147.26) 100.71,147.42 100.71,147.86 arc(100.79,148.04) 100.97,148.11 101.75,148.11 arc(102.13,148.27) 102.29,148.65 102.29,149.03 arc(102.14,149.39) 101.78,149.54 101.14,149.54 arc(100.94,149.63) 100.85,149.83 100.85,150.22 arc(100.93,150.39) 101.1,150.46 102.09,150.46 arc(102.49,150.63) 102.65,151.03 102.65,157.12 102.86,157.33 102.86,160.16 102.54,160.48 101.57,160.48 101.37,160.68 101.37,161.39 v1(101.6,161.62)
CSI_4_CLK_P: length 57.8
  TOP w0.102: J1.F48 95.2,125.36 95.33,125.49 95.33,125.85 v3(95.18,126) ; v1(100.89,161.62) 101.12,161.85 101.12,162.36 101.02,162.46 99.92,162.46 99.62,162.76 99.62,164.24 99.5,164.36 J14.43
  IN3 w0.109: v1(100.89,161.62) 101.12,161.39 101.12,160.57 101.47,160.22 102.43,160.22 102.61,160.05 102.61,157.44 102.4,157.23 102.4,151.03 arc(102.31,150.81) 102.09,150.72 101.1,150.72 arc(100.75,150.57) 100.6,150.22 100.6,149.83 arc(100.76,149.45) 101.14,149.29 101.78,149.29 arc(101.96,149.21) 102.03,149.03 102.03,148.65 arc(101.95,148.45) 101.75,148.37 100.97,148.37 arc(100.61,148.22) 100.46,147.86 100.46,147.42 arc(100.6,147.08) 100.94,146.94 102.14,146.94 arc(102.31,146.86) 102.39,146.69 102.39,146.28 arc(102.31,146.09) 102.12,146.01 100.88,146.01 arc(100.53,145.87) 100.38,145.52 100.38,145.09 arc(100.53,144.73) 100.89,144.58 102.15,144.58 arc(102.32,144.52) 102.39,144.35 102.39,143.92 arc(102.31,143.74) 102.13,143.66 98.34,143.66 95.28,140.6 95.28,131.72 94.67,131.1 94.67,129.74 94.98,129.42 94.98,128.29 95.53,127.74 95.53,127.1 95.29,126.86 95.29,126.1 v3(95.18,126)
CSI_4_D0_N: length 56.6
  TOP w0.102: v1(101.73,158.9) 101.5,159.13 101.5,159.85 101.25,160.1 99.87,160.1 98.38,161.59 98.38,164.16 98.5,164.28 J14.39 ; v3(94.08,127.41) 94.23,127.27 94.23,126.99 94.1,126.86 J1.G47
  IN3 w0.109: v1(101.73,158.9) 101.5,159.13 101.5,159.38 101.24,159.64 99.97,159.64 99.69,159.36 99.69,157.73 arc(99.82,157.4) 100.15,157.27 101.41,157.27 arc(101.56,157.2) 101.63,157.05 101.63,156.57 arc(101.56,156.41) 101.4,156.35 100.15,156.35 arc(99.82,156.21) 99.69,155.88 99.69,155.41 arc(99.83,155.06) 100.18,154.92 101.4,154.92 arc(101.56,154.85) 101.63,154.69 101.63,154.22 arc(101.56,154.06) 101.4,153.99 100.18,153.99 arc(99.83,153.85) 99.69,153.5 99.69,153.03 arc(99.83,152.7) 100.16,152.56 101.4,152.56 arc(101.56,152.5) 101.63,152.33 101.63,151.87 arc(101.56,151.71) 101.4,151.64 100.17,151.64 arc(99.83,151.5) 99.69,151.16 99.69,146.1 94.51,140.92 94.51,132.89 93.78,132.16 93.78,129.54 94.19,129.12 94.19,127.53 v3(94.08,127.41)
CSI_4_D0_P: length 56.6
  TOP w0.102: v3(94.61,127.41) 94.48,127.28 94.48,127.04 94.66,126.86 J1.G48 ; v1(101.02,158.9) 101.24,159.13 101.24,159.74 101.14,159.84 99.77,159.84 98.12,161.49 98.12,164.18 98,164.31 J14.37
  IN3 w0.109: v3(94.61,127.41) 94.46,127.56 94.46,129.21 94.03,129.64 94.03,132.06 94.76,132.79 94.76,140.81 98.19,144.24 98.39,144.24 98.62,144.47 98.62,144.67 98.86,144.91 99.06,144.91 99.29,145.14 99.29,145.34 99.94,145.99 99.94,149.07 100.08,149.21 100.08,149.54 99.94,149.68 99.94,150.01 100.08,150.15 100.08,150.48 99.94,150.62 99.94,151.16 arc(100.01,151.32) 100.17,151.39 100.48,151.39 100.62,151.25 100.95,151.25 101.09,151.39 101.4,151.39 arc(101.74,151.53) 101.88,151.87 101.88,152.33 arc(101.74,152.68) 101.4,152.82 100.16,152.82 arc(100.01,152.88) 99.94,153.03 99.94,153.5 arc(100.01,153.67) 100.18,153.74 101.4,153.74 arc(101.74,153.88) 101.88,154.22 101.88,154.69 arc(101.74,155.03) 101.4,155.17 100.18,155.17 arc(100.01,155.24) 99.94,155.41 99.94,155.88 arc(100,156.03) 100.15,156.09 101.4,156.09 arc(101.74,156.23) 101.88,156.57 101.88,157.05 arc(101.74,157.38) 101.41,157.52 101.04,157.52 100.9,157.66 100.57,157.66 100.43,157.52 100.15,157.52 arc(100,157.58) 99.94,157.73 99.94,158.26 100.08,158.4 100.08,158.73 99.94,158.87 99.94,159.25 100.08,159.38 101.14,159.38 101.24,159.28 101.24,159.13 v1(101.02,158.9)
CSI_4_D1_N: length 58.3
  TOP w0.102: v1(101.6,163.34) 101.38,163.57 101.38,164.21 101.5,164.33 J14.51 ; v3(94.62,124.5) 94.48,124.36 94.48,123.96 94.58,123.86 J1.E48
  IN3 w0.109: v3(94.62,124.5) 94.49,124.62 94.49,124.8 94.72,125.03 96.19,125.03 96.89,125.73 96.89,127.88 96.27,128.5 96.27,129.79 96.52,130.05 96.52,131.1 96.3,131.32 96.3,134.26 arc(96.41,134.51) 96.65,134.61 98.22,134.61 arc(98.6,134.77) 98.76,135.15 98.76,135.53 arc(98.61,135.9) 98.24,136.04 97.21,136.04 arc(96.99,136.13) 96.9,136.35 96.9,137.43 arc(96.99,137.65) 97.21,137.74 98.25,137.74 arc(98.64,137.9) 98.81,138.3 98.81,138.61 arc(98.64,139) 98.25,139.17 96.77,139.17 arc(96.52,139.27) 96.42,139.52 96.42,140.07 98.94,142.6 103.03,142.6 103.42,142.99 103.42,156.8 103.68,157.06 103.68,161.24 102.16,162.76 101.53,162.76 101.37,162.92 101.37,163.11 v1(101.6,163.34)
CSI_4_D1_P: length 58.3
  TOP w0.102: J1.E47 94.1,123.86 94.23,123.99 94.23,124.35 v3(94.08,124.5) ; v1(100.89,163.34) 101.12,163.57 101.12,164.21 101,164.33 J14.49
  IN3 w0.109: v1(100.89,163.34) 101.12,163.11 101.12,162.82 101.43,162.51 102.05,162.51 103.42,161.14 103.42,157.16 103.17,156.91 103.17,143.1 102.92,142.85 98.84,142.85 96.16,140.18 96.16,139.52 arc(96.34,139.09) 96.77,138.91 98.25,138.91 arc(98.46,138.82) 98.55,138.61 98.55,138.3 arc(98.46,138.08) 98.25,137.99 97.21,137.99 arc(96.81,137.83) 96.65,137.43 96.65,136.35 arc(96.81,135.95) 97.21,135.79 98.24,135.79 arc(98.43,135.72) 98.5,135.53 98.5,135.15 arc(98.42,134.95) 98.22,134.87 96.65,134.87 arc(96.23,134.69) 96.05,134.26 96.05,131.22 96.27,131 96.27,130.15 96.01,129.9 96.01,128.4 96.64,127.77 96.64,125.84 96.09,125.29 94.61,125.29 94.24,124.91 94.24,124.65 v3(94.08,124.5)
CSI_5_CLK_N: length 58.7
  TOP w0.102: J1.C45 91.92,120.86 91.78,121 91.78,121.36 v3(91.92,121.5) ; J14.67 110.5,164.37 110.38,164.25 110.38,163.59 109.83,163.04 106.05,163.04 105.94,162.94 105.94,162.74 v1(106.17,162.51)
  BOTTOM w0.102: v3(91.92,121.5) 91.78,121.63 91.78,121.83 91.98,122.04 96.4,122.04 96.9,122.54 96.9,123.3 97.65,124.05 97.65,126.57 97.3,126.92 97.3,128.31 96.52,129.09 96.52,130.92 96.39,131.04 96.39,135.15 97,135.76 97,138.27 97.87,139.14 97.87,144.44 100.15,146.72 100.15,153 105.94,158.79 105.94,162.28 v1(106.17,162.51)
CSI_5_CLK_P: length 58.7
  TOP w0.102: v3(91.38,121.5) 91.53,121.35 91.53,120.99 91.4,120.86 J1.C44 ; v1(105.46,162.51) 105.69,162.74 105.69,163.05 105.94,163.3 109.72,163.3 110.12,163.69 110.12,164.22 110,164.35 J14.65
  BOTTOM w0.102: v3(91.38,121.5) 91.52,121.63 91.52,121.94 91.88,122.29 96.29,122.29 96.65,122.65 96.65,123.41 97.39,124.15 97.39,126.47 97.05,126.81 97.05,128.2 96.27,128.99 96.27,130.81 96.14,130.94 96.14,135.25 96.75,135.86 96.75,138.38 97.61,139.24 97.61,144.54 99.9,146.83 99.9,153.1 105.69,158.9 105.69,162.28 v1(105.46,162.51)
CSI_5_D0_N: length 57.3
  TOP w0.102: J1.D43 90.31,122.36 90.18,122.49 90.18,122.86 v3(90.32,122.99) ; v1(106.58,164.01) 108.89,164.01 109,164.12 J14.61
  BOTTOM w0.102: v1(106.58,164.01) 106.35,163.78 106.35,163.32 106.07,163.04 103.38,163.04 102.79,162.45 102.79,158.14 98.6,153.95 98.6,147.33 94.44,143.17 94.44,130.08 94.95,129.57 94.95,128.51 95.78,127.68 95.78,126.94 95.45,126.61 94.39,126.61 94.23,126.46 94.23,125.52 93.9,125.19 93.4,125.19 93.09,124.88 93.09,124.42 92.3,123.64 90.38,123.64 90.18,123.43 90.18,123.13 v3(90.32,122.99)
CSI_5_D0_P: length 57.2
  TOP w0.102: v1(105.87,164.01) 103.66,164.01 103.5,164.17 J14.59 ; v3(89.78,122.99) 89.93,122.85 89.93,122.49 89.8,122.36 J1.D42
  BOTTOM w0.102: v1(105.87,164.01) 106.1,163.78 106.1,163.42 105.97,163.3 103.28,163.3 102.54,162.56 102.54,158.24 98.35,154.05 98.35,147.44 94.18,143.27 94.18,129.98 94.69,129.47 94.69,128.41 95.53,127.57 95.53,127.04 95.35,126.86 94.28,126.86 93.98,126.56 93.98,125.62 93.8,125.44 93.29,125.44 92.83,124.98 92.83,124.53 92.2,123.89 90.28,123.89 89.92,123.54 89.92,123.13 v3(89.78,122.99)
