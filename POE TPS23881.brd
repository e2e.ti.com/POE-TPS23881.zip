# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSENSA: length 3.2
  TOP w0.254: U65.4 9.27,77
  TOP w0.508: 9.27,77 8.83,77 RZ69.2 RZ66.2
KSENSB: length 4.2
  TOP w0.229: U65.11 9.11,73.5 8.61,73 8.58,73
  TOP w0.508: 8.58,73 RZ202.2 RZ200.2
KSENSC: length 3.2
  TOP w0.203: 19.44,73.5 U65.32
  TOP w0.254: RZ77.2 19.44,73.5
  TOP w0.508: RZ77.2 RZ75.2
KSENSD: length 3.6
  TOP w0.229: 19.84,77 U65.39
  TOP w0.508: 19.84,77 20.21,77 20.52,77.32 RZ71.2 RZ70.2
LAN1_ACT#: length 1.7
  BOTTOM w0.107: U41.30 27.31,38.39 R286.2
LAN1_CBOT: length 2
  BOTTOM w0.229: U41.37 29.66,34.64 29.78,34.76 30.48,34.76 C171.2
LAN1_CT1_A+_V-:
  vias: v1(10.16,10.67) v1(10.16,10.08) v1(10.16,9.5)
LAN1_CT2_A-_V+: length 2.8
  BOTTOM w0.813: U57.21 15.11,9.65
  vias: v1(14.68,11.25) v1(15.37,11.86) v1(15.37,11.25)
LAN1_CT3_B+_V+: length 3.4
  BOTTOM w0.762: U57.18 18.92,10.29
  vias: v1(6.55,9.73) v1(7.32,9.73) v1(18.29,11.25) v1(18.87,11.25) v1(19.51,11.25)
LAN1_CT4_B-_V-: length 3.2
  BOTTOM w0.762: 22.94,9.98 22.73,9.78 U57.15
  vias: v1(6.67,5.8) v1(7.44,5.79) v1(22.45,11.25) v1(23.06,11.25) v1(23.7,11.25)
LAN1_CTOP: length 1.9
  BOTTOM w0.229: 30.16,33.14 U41.40
  BOTTOM w0.305: 30.16,33.14 30.56,33.14 C171.1
LAN1_DEV_OFF: length 2.4
  TOP w0.107: R270.1 26.42,37.69 26.29,37.82 v1(26.29,38.3)
  BOTTOM w0.107: U41.28 26.31,38.28 v1(26.29,38.3) R269.2
LAN1_LINK_100#: length 2.1
  BOTTOM w0.107: U41.31 27.81,37.97 28.73,38.89 R288.2
LAN1_LINK_1000#: length 3.3
  BOTTOM w0.107: R289.2 32,36.37 31.42,36.96 30.23,36.96 29.91,36.64 U41.33
LAN1_MDI0+: length 16.4
  BOTTOM w0.089: U57.2 12.57,21.89 13.08,22.4 13.08,23.01 13.45,23.39 15.58,23.39 17.03,24.84 22.88,24.84 22.97,24.93 22.97,25.02 22.88,25.11 D16.10 D16.1 22.88,26.48 22.99,26.59 22.99,26.84 23.93,27.77 23.93,27.91 23.81,28.03 U41.58
LAN1_MDI0+_T: length 5.3
  BOTTOM w0.762: 12.47,5.21 12.47,5.66 12.57,5.77 U57.23
  BOTTOM w1.016: POE1.8 10.87,3.33 12.47,4.93 12.47,5.21
LAN1_MDI0-: length 16.4
  BOTTOM w0.089: U41.57 24.31,27.99 24.21,27.89 24.21,27.66 23.27,26.72 23.27,26.59 23.38,26.48 D16.2 D16.9 23.38,25.15 23.25,25.03 23.25,24.81 22.99,24.56 17.14,24.56 15.69,23.11 13.57,23.11 13.36,22.9 13.36,22.4 13.84,21.92 U57.3
LAN1_MDI0-_T: length 5
  BOTTOM w0.762: 13.92,5.18 13.92,5.66 13.84,5.74 U57.22
  BOTTOM w1.016: 13.92,5.18 13.92,4.42 12.87,3.37 POE1.7
LAN1_MDI1+: length 14.5
  BOTTOM w0.089: U41.55 25.31,27.93 25.42,27.82 25.42,27.22 25.26,27.06 24.74,27.06 24.49,26.81 24.49,26.56 24.38,26.45 D16.4 D16.7 24.38,25.1 24.49,24.99 24.49,24.82 24.38,24.71 24.01,24.71 23.26,23.96 17.8,23.96 16.88,23.04 16.88,22.49 16.38,22 U57.5
LAN1_MDI1+_T: length 5.2
  BOTTOM w0.762: 16.28,5.21 16.28,5.66 16.38,5.77 U57.20
  BOTTOM w1.016: POE1.6 14.87,3.31 16.28,4.72 16.28,5.21
LAN1_MDI1-: length 14.5
  BOTTOM w0.089: U41.54 25.81,27.97 25.7,27.86 25.7,27.11 25.38,26.78 24.85,26.78 24.77,26.69 24.77,26.57 24.88,26.46 D16.5 D16.6 24.88,25.1 24.77,24.99 24.77,24.7 24.5,24.43 24.13,24.43 23.38,23.69 17.92,23.69 17.16,22.92 17.16,22.5 17.65,22 U57.6
LAN1_MDI1-_T: length 5
  BOTTOM w0.762: 17.73,5.18 17.73,5.66 17.65,5.74 U57.19
  BOTTOM w1.016: 17.73,5.18 17.73,4.09 16.87,3.23 POE1.5
LAN1_MDI2+: length 12.2
  BOTTOM w0.089: U57.8 20.19,21.97 20.69,22.47 20.69,22.79 20.99,23.09 23.7,23.09 24.41,23.8 26.09,23.8 26.39,24.1 26.39,24.94 26.25,25.08 D19.10 D19.1 26.25,26.41 26.37,26.52 26.37,27.42 26.42,27.48 26.42,27.86 26.31,27.97 U41.53
LAN1_MDI2+_T: length 5.1
  BOTTOM w0.762: 20.09,5.21 20.09,5.66 20.19,5.77 U57.17
  BOTTOM w1.016: 20.09,5.21 20.09,4.32 18.87,3.1 POE1.4
LAN1_MDI2-: length 12.2
  BOTTOM w0.089: U57.9 21.46,21.97 20.97,22.47 20.97,22.67 21.1,22.81 23.81,22.81 24.53,23.52 26.2,23.52 26.67,23.99 26.67,24.94 26.75,25.03 D19.9 D19.2 26.75,26.41 26.64,26.52 26.64,27.3 26.7,27.36 26.7,27.84 26.81,27.95 U41.52
LAN1_MDI2-_T: length 4.9
  BOTTOM w0.762: U57.16 21.46,5.74 21.54,5.66 21.54,5.18
  BOTTOM w1.016: 21.54,5.18 21.54,3.61 20.87,2.94 POE1.3
LAN1_MDI3+: length 10.2
  BOTTOM w0.089: U41.50 27.81,27.94 27.92,27.83 27.92,27.1 27.86,27.04 27.86,26.54 27.75,26.43 D19.4 D19.7 27.75,25.08 27.86,24.97 27.86,23.39 27.38,22.91 24.78,22.91 24.52,22.66 24.52,22.47 24,21.95 U57.11
LAN1_MDI3+_T: length 5
  BOTTOM w0.762: U57.14 24,5.77 23.9,5.66 23.9,5.21
  BOTTOM w1.016: 23.9,5.21 23.9,4.06 22.87,3.03 POE1.2
LAN1_MDI3-: length 10.2
  BOTTOM w0.089: U57.12 25.27,21.97 24.8,22.44 24.8,22.54 24.89,22.63 27.5,22.63 28.14,23.28 28.14,24.94 28.25,25.05 D19.6 D19.5 28.25,26.43 28.14,26.54 28.14,26.92 28.2,26.98 28.2,27.85 28.31,27.96 U41.49
LAN1_MDI3-_T: length 4.8
  BOTTOM w0.762: U57.13 25.27,5.74 25.35,5.66 25.35,5.18
  BOTTOM w1.016: 25.35,5.18 25.35,3.4 24.87,2.92 POE1.1
LAN1_NVM_CS: length 1.4
  TOP w0.107: U42.1 18.15,39.99 v1(18.29,40.13)
  BOTTOM w0.107: R284.1 v1(18.29,40.13)
LAN1_NVM_SI: length 5.8
  TOP w0.107: R290.2 17.17,34.57 v1(17.14,34.54) 16.65,35.04 U42.5
  BOTTOM w0.107: R281.1 v1(17.14,34.54) 16.64,35.05 R291.1
LAN1_NVM_SK: length 3.6
  TOP w0.107: U42.6 17.15,35.18 v1(17.14,35.18)
  BOTTOM w0.107: R282.1 v1(17.14,35.18) 17.14,35.76 17.27,35.89 R287.2
LAN1_NVM_SO: length 1.4
  TOP w0.107: U42.2 v1(17.65,40.13)
  BOTTOM w0.107: R283.1 17.65,40.13 v1(17.65,40.13)
LAN1_PWR_GOOD: length 1.5
  BOTTOM w0.107: U41.1 19.49,29.14 19.43,29.08 18.68,29.08 R275.2
LAN1_VDD0P9_OUT: length 3.9
  TOP w0.508: RZ128.1 29.08,35.1 C166.1 29.06,34.8 29.57,34.29 v1(29.97,34.29)
  BOTTOM w0.229: U41.38 29.82,34.14 v1(29.97,34.29)
LAN1_VDD1P5_OUT: length 3.9
  TOP w0.508: v1(29.97,33.62) 29.27,33.62 C167.1 29.59,32.87 RZ135.1
  BOTTOM w0.229: v1(29.97,33.62) 29.95,33.64 U41.39
LAN1_XTAL1: length 5.6
  BOTTOM w0.203: U41.46 29.55,30.14 29.65,30.04 31.67,30.04 R285.2 31.86,29.24 C174.1 31.58,27.63 X2.1
LAN1_XTAL2: length 2.9
  BOTTOM w0.203: RB14.1 31.79,30.4 29.83,30.4 29.59,30.64 U41.45
LAN2_ACT#: length 1.7
  BOTTOM w0.107: R310.2 44.08,35.47 U43.30
LAN2_CBOT: length 1.9
  BOTTOM w0.229: U43.37 46.42,31.72 46.54,31.84 47.37,31.84 C180.2
LAN2_CT1_A+_V-:
  vias: v1(32.31,10.69) v1(32.31,10.08)
LAN2_CT2_A-_V+:
  vias: v1(36.78,11.25) v1(37.41,11.25)
LAN2_CTOP: length 1.9
  BOTTOM w0.229: 46.93,30.22 U43.40
  BOTTOM w0.305: C180.1 47.2,30.22 46.93,30.22
LAN2_DEV_OFF: length 2.5
  TOP w0.107: R295.1 43.18,34.77 43.05,34.9 v1(43.05,35.38)
  BOTTOM w0.107: R293.2 v1(43.05,35.38) 43.08,35.36 U43.28
LAN2_LINK_100#: length 2.1
  BOTTOM w0.107: R312.2 45.49,35.97 44.58,35.05 U43.31
LAN2_LINK_1000#: length 1.8
  BOTTOM w0.107: R313.2 46.32,33.72 U43.33
LAN2_MDI0+: length 10.9
  BOTTOM w0.089: U58.2 35.38,18.74 35.74,19.1 35.74,19.42 37.81,21.49 39.79,21.49 40.26,21.96 40.26,22.07 40.15,22.18 D21.10 D21.1 40.15,23.54 40.26,23.65 40.26,24.14 40.69,24.57 40.69,24.94 40.58,25.05 U43.58
LAN2_MDI0+_T: length 8.5
  BOTTOM w0.635: U58.23 35.38,7.6 35.14,7.35 35.14,7.2
  BOTTOM w0.762: POE2.8 30.87,2.7 35.14,6.97 35.14,7.2
LAN2_MDI0-: length 10.9
  BOTTOM w0.089: U43.57 41.08,25.07 40.97,24.96 40.97,24.46 40.54,24.03 40.54,23.65 40.65,23.54 D21.2 D21.9 40.65,22.21 40.54,22.1 40.54,21.84 39.9,21.21 37.92,21.21 36.02,19.3 36.02,19.13 36.38,18.77 U58.3
LAN2_MDI0-_T: length 8.2
  BOTTOM w0.635: 36.59,7.22 36.59,7.35 36.38,7.56 U58.22
  BOTTOM w0.762: POE2.7 32.87,2.74 36.59,6.47 36.59,7.22
LAN2_MDI1+: length 9.9
  BOTTOM w0.089: U43.55 42.08,25.03 42.19,24.92 42.19,24.45 41.76,24.02 41.76,23.65 41.65,23.54 D21.4 D21.7 41.65,22.23 41.76,22.12 41.76,21.45 40.63,20.32 39.24,20.32 38.74,19.82 38.74,19.05 38.38,18.69 U58.5
LAN2_MDI1+_T: length 8.1
  BOTTOM w0.635: U58.20 38.38,7.57 38.16,7.35 38.16,7.2
  BOTTOM w0.762: 38.16,7.2 38.16,6.06 34.87,2.76 POE2.6
LAN2_MDI1-: length 9.9
  BOTTOM w0.089: U43.54 42.58,25.03 42.47,24.92 42.47,24.33 42.04,23.9 42.04,23.67 42.15,23.56 D21.5 D21.6 42.15,22.23 42.04,22.12 42.04,21.34 40.74,20.04 39.36,20.04 39.02,19.7 39.02,19.05 39.38,18.69 U58.6
LAN2_MDI1-_T: length 7.8
  BOTTOM w0.635: U58.19 39.38,7.59 39.62,7.35 39.62,7.22
  BOTTOM w0.762: 39.62,7.22 39.62,5.68 36.87,2.93 POE2.5
LAN2_MDI2+: length 8.6
  BOTTOM w0.089: U43.53 43.08,25.12 43.19,25.01 43.19,24.25 43.56,23.88 43.56,23.62 43.45,23.51 D23.1 D23.10 43.45,22.16 43.56,22.05 43.56,21.7 41.73,19.87 41.73,19.1 41.38,18.75 U58.8
LAN2_MDI2+_T: length 7.6
  BOTTOM w0.635: U58.17 41.38,7.57 41.16,7.35 41.16,7.2
  BOTTOM w0.762: POE2.4 38.87,2.85 41.16,5.15 41.16,7.2
LAN2_MDI2-: length 8.6
  BOTTOM w0.089: U43.52 43.58,25.12 43.47,25.01 43.47,24.37 43.84,23.99 43.84,23.62 43.95,23.51 D23.2 D23.9 43.95,22.16 43.84,22.05 43.84,21.58 42.01,19.75 42.01,19.1 42.38,18.73 U58.9
LAN2_MDI2-_T: length 7.4
  BOTTOM w0.635: U58.16 42.38,7.59 42.62,7.35 42.62,7.22
  BOTTOM w0.762: 42.62,7.22 42.62,4.67 40.87,2.92 POE2.3
LAN2_MDI3+: length 7.9
  BOTTOM w0.089: U58.11 44.38,18.7 44.74,19.06 44.74,19.75 45.06,20.07 45.06,22.05 44.95,22.16 D23.7 D23.4 44.95,23.56 45.06,23.67 45.06,24.21 44.69,24.58 44.69,24.96 44.58,25.07 U43.50
LAN2_MDI3+_T: length 7.2
  BOTTOM w0.635: U58.14 44.38,7.57 44.16,7.35 44.16,7.2
  BOTTOM w0.762: 44.16,7.2 44.16,4.23 42.87,2.94 POE2.2
LAN2_MDI3-: length 7.9
  BOTTOM w0.089: U43.49 45.08,25.09 44.97,24.98 44.97,24.7 45.34,24.32 45.34,23.67 45.45,23.56 D23.5 D23.6 45.45,22.16 45.34,22.05 45.34,19.96 45.02,19.63 45.02,19.06 45.38,18.7 U58.12
LAN2_MDI3-_T: length 7
  BOTTOM w0.635: U58.13 45.38,7.59 45.62,7.35 45.62,7.22
  BOTTOM w0.762: 45.62,7.22 45.62,3.01 POE2.1
LAN2_NVM_CS: length 1.4
  TOP w0.107: U44.1 34.91,37.07 v1(35.05,37.21)
  BOTTOM w0.107: R308.1 v1(35.05,37.21)
LAN2_NVM_SI: length 5.8
  TOP w0.107: R314.2 v1(33.91,31.62) 33.41,32.12 U44.5
  BOTTOM w0.107: R305.1 v1(33.91,31.62) 33.4,32.13 R315.1
LAN2_NVM_SK: length 3.6
  TOP w0.107: U44.6 33.91,32.26 v1(33.91,32.26)
  BOTTOM w0.107: R306.1 v1(33.91,32.26) 33.91,32.89 34.04,33.02 R311.2
LAN2_NVM_SO: length 1.4
  TOP w0.107: v1(34.41,37.21) U44.2
  BOTTOM w0.107: R307.1 34.42,37.21 v1(34.41,37.21)
LAN2_PWR_GOOD: length 1.5
  BOTTOM w0.107: U43.1 36.25,26.22 36.2,26.16 35.45,26.16 R299.2
LAN2_VDD0P9_OUT: length 3.9
  TOP w0.508: v1(46.74,31.37) 46.33,31.37 45.82,31.88 C175.1 45.85,32.18 RZ130.1
  BOTTOM w0.229: U43.38 46.59,31.22 v1(46.74,31.37)
LAN2_VDD1P5_OUT: length 3.8
  TOP w0.508: RZ137.1 46.35,29.95 C176.1 46.04,30.7 v1(46.74,30.7)
  BOTTOM w0.229: v1(46.74,30.7) 46.71,30.72 U43.39
LAN2_XTAL1: length 5.6
  BOTTOM w0.203: U43.46 46.31,27.22 46.42,27.12 48.44,27.12 R309.2 48.63,26.31 C183.1 48.35,24.71 X3.1
LAN2_XTAL2: length 2.9
  BOTTOM w0.203: U43.45 46.35,27.72 46.59,27.48 48.55,27.48 RB15.1
LAN3_ACT#: length 1.7
  BOTTOM w0.107: U45.30 62.36,35.47 R333.2
LAN3_CBOT: length 1.9
  BOTTOM w0.229: C189.2 65.66,31.84 64.83,31.84 64.71,31.72 U45.37
LAN3_CT1_A+_V-:
  vias: v1(52.48,10.46) v1(52.48,9.86)
LAN3_CT2_A-_V+:
  vias: v1(57,11.25) v1(57.63,11.25)
LAN3_CTOP: length 1.9
  BOTTOM w0.229: 65.21,30.22 U45.40
  BOTTOM w0.305: 65.21,30.22 65.49,30.22 C189.1
LAN3_DEV_OFF: length 2.5
  TOP w0.107: R318.1 61.47,34.77 61.34,34.9 v1(61.34,35.38)
  BOTTOM w0.107: U45.28 61.36,35.36 v1(61.34,35.38) R317.2
LAN3_LINK_100#: length 2.1
  BOTTOM w0.107: R336.2 63.78,35.97 62.86,35.05 U45.31
LAN3_LINK_1000#: length 1.8
  BOTTOM w0.107: U45.33 64.61,33.72 R337.2
LAN3_MDI0+: length 8.9
  BOTTOM w0.089: U59.2 55.57,18.77 55.94,19.14 55.94,19.36 58.55,21.96 58.55,22.07 58.44,22.18 D24.10 D24.1 58.44,23.54 58.55,23.65 58.55,24.14 58.97,24.57 58.97,24.94 58.86,25.05 U45.58
LAN3_MDI0+_T: length 8.5
  BOTTOM w0.635: 55.33,7.2 55.33,7.35 55.57,7.6 U59.23
  BOTTOM w0.762: 55.33,7.2 55.33,6.97 50.87,2.51 POE3.8
LAN3_MDI0-: length 8.9
  BOTTOM w0.089: U59.3 56.57,18.77 56.22,19.11 56.22,19.24 58.83,21.84 58.83,22.1 58.94,22.21 D24.9 D24.2 58.94,23.54 58.83,23.65 58.83,24.03 59.25,24.46 59.25,24.96 59.36,25.07 U45.57
LAN3_MDI0-_T: length 8.3
  BOTTOM w0.635: U59.22 56.57,7.56 56.79,7.35 56.79,7.22
  BOTTOM w0.762: POE3.7 52.87,2.55 56.79,6.47 56.79,7.22
LAN3_MDI1+: length 8.3
  BOTTOM w0.089: U45.55 60.36,25.03 60.47,24.92 60.47,24.45 60.05,24.02 60.05,23.65 59.94,23.54 D24.4 D24.7 59.94,22.23 60.05,22.12 60.05,21.31 58.93,20.2 58.93,19.05 58.57,18.69 U59.5
LAN3_MDI1+_T: length 8.1
  BOTTOM w0.635: U59.20 58.57,7.57 58.35,7.35 58.35,7.2
  BOTTOM w0.762: POE3.6 54.87,2.57 58.35,6.06 58.35,7.2
LAN3_MDI1-: length 8.3
  BOTTOM w0.089: U59.6 59.57,18.71 59.21,19.07 59.21,20.08 60.33,21.2 60.33,22.12 60.44,22.23 D24.6 D24.5 60.44,23.56 60.33,23.67 60.33,23.9 60.75,24.33 60.75,24.92 60.86,25.03 U45.54
LAN3_MDI1-_T: length 7.9
  BOTTOM w0.635: 59.81,7.22 59.81,7.35 59.57,7.59 U59.19
  BOTTOM w0.762: 59.81,7.22 59.81,5.68 56.87,2.74 POE3.5
LAN3_MDI2+: length 7.8
  BOTTOM w0.089: U59.8 61.57,18.77 61.93,19.13 61.93,20.48 61.85,20.56 61.85,22.05 61.74,22.16 D27.10 D27.1 61.74,23.51 61.85,23.62 61.85,23.88 61.47,24.25 61.47,25.01 61.36,25.12 U45.53
LAN3_MDI2+_T: length 7.7
  BOTTOM w0.635: 61.36,7.2 61.36,7.35 61.57,7.57 U59.17
  BOTTOM w0.762: POE3.4 58.87,2.66 61.36,5.15 61.36,7.2
LAN3_MDI2-: length 7.8
  BOTTOM w0.089: U45.52 61.86,25.12 61.75,25.01 61.75,24.37 62.13,23.99 62.13,23.62 62.24,23.51 D27.2 D27.9 62.24,22.16 62.13,22.05 62.13,20.68 62.21,20.6 62.21,19.13 62.57,18.77 U59.9
LAN3_MDI2-_T: length 7.5
  BOTTOM w0.635: 62.81,7.22 62.81,7.35 62.57,7.59 U59.16
  BOTTOM w0.762: POE3.3 60.87,2.73 62.81,4.67 62.81,7.22
LAN3_MDI3+: length 8.5
  BOTTOM w0.089: U59.11 64.57,18.66 64.93,19.02 64.93,20.02 63.35,21.6 63.35,22.05 63.24,22.16 D27.7 D27.4 63.24,23.56 63.35,23.67 63.35,24.21 62.97,24.58 62.97,24.96 62.86,25.07 U45.50
LAN3_MDI3+_T: length 7.3
  BOTTOM w0.635: 64.36,7.2 64.36,7.35 64.57,7.57 U59.14
  BOTTOM w0.762: POE3.2 62.87,2.75 64.36,4.23 64.36,7.2
LAN3_MDI3-: length 8.5
  BOTTOM w0.089: U59.12 65.57,18.66 65.21,19.02 65.21,20.13 63.63,21.72 63.63,22.05 63.74,22.16 D27.6 D27.5 63.74,23.56 63.63,23.67 63.63,24.32 63.25,24.7 63.25,24.98 63.36,25.09 U45.49
LAN3_MDI3-_T: length 7.1
  BOTTOM w0.635: U59.13 65.57,7.59 65.81,7.35 65.81,7.22
  BOTTOM w0.762: POE3.1 64.87,2.72 65.81,3.66 65.81,7.22
LAN3_NVM_CS: length 1.4
  TOP w0.107: U46.1 53.2,37.07 v1(53.34,37.21)
  BOTTOM w0.107: R332.1 v1(53.34,37.21)
LAN3_NVM_SI: length 5.8
  TOP w0.107: R338.2 52.72,31.62 v1(52.2,31.62) 51.7,32.12 U46.5
  BOTTOM w0.107: R329.1 v1(52.2,31.62) 51.69,32.13 R339.1
LAN3_NVM_SK: length 3.6
  TOP w0.107: U46.6 52.2,32.26 v1(52.2,32.26)
  BOTTOM w0.107: R330.1 v1(52.2,32.26) 52.2,32.89 52.32,33.02 R335.2
LAN3_NVM_SO: length 1.4
  TOP w0.107: v1(52.7,37.21) U46.2
  BOTTOM w0.107: R331.1 52.7,37.21 v1(52.7,37.21)
LAN3_PWR_GOOD: length 1.5
  BOTTOM w0.107: U45.1 54.54,26.22 54.48,26.16 53.73,26.16 R323.2
LAN3_VDD0P9_OUT: length 3.9
  TOP w0.508: RZ131.1 64.14,32.18 C184.1 64.11,31.88 64.62,31.37 v1(65.02,31.37)
  BOTTOM w0.229: U45.38 64.88,31.22 v1(65.02,31.37)
LAN3_VDD1P5_OUT: length 3.8
  TOP w0.508: RZ138.1 64.64,29.95 C185.1 64.33,30.7 v1(65.02,30.7)
  BOTTOM w0.229: v1(65.02,30.7) 65,30.72 U45.39
LAN3_XTAL1: length 5.6
  BOTTOM w0.203: X4.1 66.64,24.71 C192.1 66.92,26.31 R334.2 66.72,27.12 64.71,27.12 64.6,27.22 U45.46
LAN3_XTAL2: length 2.9
  BOTTOM w0.203: RB16.1 66.84,27.48 64.88,27.48 64.64,27.72 U45.45
LAN4_ACT#: length 1.7
  BOTTOM w0.107: U47.30 80.65,35.47 R356.2
LAN4_CBOT: length 1.9
  BOTTOM w0.229: U47.37 83,31.72 83.12,31.84 83.95,31.84 C198.2
LAN4_CT1_A+_V-:
  vias: v1(72.69,10.59) v1(72.69,9.96)
LAN4_CT2_A-_V+:
  vias: v1(77.19,11.25) v1(77.83,11.25)
LAN4_CTOP: length 1.9
  BOTTOM w0.229: U47.40 83.5,30.22
  BOTTOM w0.305: 83.5,30.22 83.78,30.22 C198.1
LAN4_DEV_OFF: length 2.5
  TOP w0.107: v1(79.63,35.38) 79.63,35.18 79.76,35.05 R343.1
  BOTTOM w0.107: U47.28 79.65,35.36 v1(79.63,35.38) R341.2
LAN4_LINK_100#: length 2.1
  BOTTOM w0.107: U47.31 81.15,35.05 82.07,35.97 R360.2
LAN4_LINK_1000#: length 1.9
  BOTTOM w0.107: U47.33 83.13,33.72 83.85,34.44 R361.2
LAN4_MDI0+: length 8.1
  BOTTOM w0.089: U60.2 75.76,18.74 76.12,19.1 76.12,20.12 76.83,20.83 76.83,21.97 76.72,22.08 D29.10 D29.1 76.72,23.54 76.83,23.65 76.83,24.14 77.26,24.57 77.26,24.95 77.15,25.06 U47.58
LAN4_MDI0+_T: length 9
  BOTTOM w0.635: U60.23 75.76,7.6 75.52,7.35 75.52,7.2
  BOTTOM w0.762: POE4.8 70.87,2.9 72.42,4.45 73,4.45 75.52,6.97 75.52,7.2
LAN4_MDI0-: length 8.1
  BOTTOM w0.089: U47.57 77.65,25.07 77.54,24.96 77.54,24.46 77.11,24.03 77.11,23.65 77.22,23.54 D29.2 D29.9 77.22,22.11 77.11,22 77.11,20.71 76.4,20 76.4,19.13 76.76,18.77 U60.3
LAN4_MDI0-_T: length 8.4
  BOTTOM w0.635: 76.98,7.22 76.98,7.35 76.76,7.56 U60.22
  BOTTOM w0.762: POE4.7 72.87,2.43 76.98,6.55 76.98,7.22
LAN4_MDI1+: length 8.1
  BOTTOM w0.089: U47.55 78.65,25.03 78.76,24.92 78.76,24.45 78.33,24.02 78.33,23.65 78.22,23.54 D29.4 D29.7 78.22,22.11 78.33,22 78.33,20.56 79.12,19.77 79.12,19.05 78.76,18.69 U60.5
LAN4_MDI1+_T: length 8.2
  BOTTOM w0.635: U60.20 78.76,7.57 78.55,7.35 78.55,7.2
  BOTTOM w0.762: 78.55,7.2 78.55,6.06 74.87,2.38 POE4.6
LAN4_MDI1-: length 8.1
  BOTTOM w0.089: U47.54 79.15,25.03 79.04,24.92 79.04,24.33 78.61,23.9 78.61,23.67 78.72,23.56 D29.5 D29.6 78.72,22.08 78.61,21.97 78.61,20.68 79.4,19.89 79.4,19.05 79.76,18.69 U60.6
LAN4_MDI1-_T: length 8
  BOTTOM w0.635: 80.01,7.22 80.01,7.35 79.76,7.59 U60.19
  BOTTOM w0.762: 80.01,7.22 80.01,5.68 76.87,2.55 POE4.5
LAN4_MDI2+: length 8.6
  BOTTOM w0.089: U60.8 81.76,18.74 82.12,19.1 82.12,19.33 80.14,21.32 80.14,21.97 80.03,22.08 D31.10 D31.1 80.03,23.51 80.14,23.62 80.14,23.88 79.76,24.25 79.76,25.01 79.65,25.12 U47.53
LAN4_MDI2+_T: length 7.8
  BOTTOM w0.635: 81.55,7.2 81.55,7.35 81.76,7.57 U60.17
  BOTTOM w0.762: 81.55,7.2 81.55,5.37 78.87,2.69 POE4.4
LAN4_MDI2-: length 8.6
  BOTTOM w0.089: U60.9 82.76,18.73 82.4,19.09 82.4,19.45 80.42,21.44 80.42,22 80.53,22.11 D31.9 D31.2 80.53,23.51 80.42,23.62 80.42,23.99 80.04,24.37 80.04,25.01 80.15,25.12 U47.52
LAN4_MDI2-_T: length 7.6
  BOTTOM w0.635: U60.16 82.76,7.59 83.01,7.35 83.01,7.22
  BOTTOM w0.762: POE4.3 80.87,2.84 83.01,4.98 83.01,7.22
LAN4_MDI3+: length 9.9
  BOTTOM w0.089: U60.11 84.76,18.72 85.12,19.08 85.12,19.25 83.69,20.69 82.52,20.69 81.64,21.58 81.64,22 81.53,22.11 D31.7 D31.4 81.53,23.56 81.64,23.67 81.64,24.21 81.26,24.58 81.26,24.96 81.15,25.07 U47.50
LAN4_MDI3+_T: length 7.4
  BOTTOM w0.635: U60.14 84.76,7.57 84.55,7.35 84.55,7.2
  BOTTOM w0.762: 84.55,7.2 84.55,4.51 82.87,2.83 POE4.2
LAN4_MDI3-: length 9.9
  BOTTOM w0.089: U47.49 81.65,25.09 81.54,24.98 81.54,24.7 81.92,24.32 81.92,23.67 82.03,23.56 D31.5 D31.6 82.03,22.08 81.92,21.97 81.92,21.7 82.64,20.97 83.8,20.97 85.4,19.37 85.4,19.02 85.76,18.66 U60.12
LAN4_MDI3-_T: length 7.2
  BOTTOM w0.635: U60.13 85.76,7.59 86.01,7.35 86.01,7.22
  BOTTOM w0.762: 86.01,7.22 86.01,4.01 84.87,2.88 POE4.1
LAN4_NVM_CS: length 2.2
  TOP w0.107: U48.1 71.49,37.07 71.63,37.22 v1(71.63,37.59)
  BOTTOM w0.107: R357.1 71.63,37.59 v1(71.63,37.59)
LAN4_NVM_SI: length 5.9
  TOP w0.107: U48.5 69.99,31.88 70.25,31.62 v1(70.48,31.62) 70.51,31.65 R362.2
  BOTTOM w0.107: R363.1 69.98,32.13 v1(70.48,31.62) R353.1
LAN4_NVM_SK: length 3.6
  TOP w0.107: v1(70.48,32.26) 70.49,32.26 U48.6
  BOTTOM w0.107: R354.1 v1(70.48,32.26) 70.48,32.89 70.61,33.02 R359.2
LAN4_NVM_SO: length 2.1
  TOP w0.107: v1(70.99,37.59) 70.99,37.59 U48.2
  BOTTOM w0.107: R355.1 v1(70.99,37.59)
LAN4_PWR_GOOD: length 1.9
  BOTTOM w0.107: U47.1 72.96,26.22 72.65,25.91 71.66,25.91 R347.2
LAN4_VDD0P9_OUT: length 3.9
  TOP w0.508: RZ132.1 82.42,32.18 C193.1 82.4,31.88 82.91,31.37 v1(83.31,31.37)
  BOTTOM w0.254: v1(83.31,31.37) 83.16,31.22 U47.38
LAN4_VDD1P5_OUT: length 3.8
  TOP w0.508: RZ139.1 82.93,29.95 C194.1 82.61,30.7 v1(83.31,30.7)
  BOTTOM w0.254: U47.39 83.29,30.72 v1(83.31,30.7)
LAN4_XTAL1: length 5.6
  BOTTOM w0.203: U47.46 82.89,27.22 82.99,27.12 85.01,27.12 R358.2 85.2,26.31 C201.1 84.92,25.36 84.64,25.08 X5.1
LAN4_XTAL2: length 2.9
  BOTTOM w0.203: RB17.1 85.13,27.48 83.17,27.48 82.93,27.72 U47.45
LAN5_ACT#: length 1.7
  BOTTOM w0.107: R381.2 98.94,35.47 U49.30
LAN5_CBOT: length 1.9
  BOTTOM w0.229: C206.2 102.23,31.84 101.41,31.84 101.29,31.72 U49.37
LAN5_CT1_A+_V-:
  vias: v1(92.84,10.52) v1(92.86,9.91)
LAN5_CT2_A-_V+:
  vias: v1(97.38,11.25) v1(98.02,11.25)
LAN5_CTOP: length 1.9
  BOTTOM w0.229: U49.40 101.79,30.22
  BOTTOM w0.305: 101.79,30.22 102.07,30.22 C206.1
LAN5_DEV_OFF: length 2.5
  TOP w0.107: v1(97.92,35.38) 97.92,35.05 98.04,34.92 R366.1
  BOTTOM w0.107: R364.2 v1(97.92,35.38) 97.94,35.36 U49.28
LAN5_LINK_100#: length 2.1
  BOTTOM w0.107: R384.2 100.36,35.97 99.44,35.05 U49.31
LAN5_LINK_1000#: length 1.8
  BOTTOM w0.107: R385.2 101.18,33.72 U49.33
LAN5_MDI0+: length 8.3
  BOTTOM w0.089: U61.2 95.96,18.74 96.32,19.1 96.32,19.7 95.12,20.89 95.12,22.05 95.01,22.16 D32.10 D32.1 95.01,23.54 95.12,23.65 95.12,24.14 95.55,24.57 95.55,24.92 95.44,25.03 U49.58
LAN5_MDI0+_T: length 9.2
  BOTTOM w0.635: 95.72,7.2 95.72,7.35 95.96,7.6 U61.23
  BOTTOM w0.762: POE5.8 90.87,3.11 93.68,5.92 94.54,5.92 95.72,7.09 95.72,7.2
LAN5_MDI0-: length 8.3
  BOTTOM w0.089: U61.3 96.96,18.76 96.6,19.12 96.6,19.81 95.4,21.01 95.4,22.02 95.51,22.13 D32.9 D32.2 95.51,23.54 95.4,23.65 95.4,24.03 95.83,24.46 95.83,24.94 95.94,25.05 U49.57
LAN5_MDI0-_T: length 8.9
  BOTTOM w0.635: U61.22 96.96,7.56 97.17,7.35 97.17,7.22
  BOTTOM w0.762: POE5.7 92.87,3.11 94.06,4.29 94.77,4.29 97.17,6.7 97.17,7.22
LAN5_MDI1+: length 9.5
  BOTTOM w0.089: U49.55 96.94,25.06 97.05,24.95 97.05,24.45 96.62,24.02 96.62,23.65 96.51,23.54 D32.4 D32.7 96.51,22.16 96.62,22.05 96.62,20.91 97.44,20.1 98.46,20.1 99.32,19.24 99.32,19.07 98.96,18.71 U61.5
LAN5_MDI1+_T: length 8.3
  BOTTOM w0.635: 98.74,7.2 98.74,7.35 98.96,7.57 U61.20
  BOTTOM w0.762: 98.74,7.2 98.74,6.36 94.87,2.49 POE5.6
LAN5_MDI1-: length 9.5
  BOTTOM w0.089: U61.6 99.96,18.69 99.6,19.05 99.6,19.36 98.58,20.38 97.55,20.38 96.9,21.03 96.9,22.02 97.01,22.13 D32.6 D32.5 97.01,23.56 96.9,23.67 96.9,23.9 97.33,24.33 97.33,24.94 97.44,25.05 U49.54
LAN5_MDI1-_T: length 8.1
  BOTTOM w0.635: U61.19 99.96,7.59 100.2,7.35 100.2,7.22
  BOTTOM w0.762: 100.2,7.22 100.2,5.91 96.87,2.58 POE5.5
LAN5_MDI2+: length 10.6
  BOTTOM w0.089: U49.53 97.94,25.05 98.05,24.94 98.05,24.25 98.42,23.88 98.42,23.75 98.31,23.64 D35.1 D35.10 98.31,22.21 98.42,22.1 98.42,21.46 100.08,19.81 102.1,19.81 102.32,19.59 102.32,19.09 101.96,18.73 U61.8
LAN5_MDI2+_T: length 7.9
  BOTTOM w0.635: 101.74,7.2 101.74,7.35 101.96,7.57 U61.17
  BOTTOM w0.762: POE5.4 98.87,2.73 101.74,5.6 101.74,7.2
LAN5_MDI2-: length 10.6
  BOTTOM w0.089: U61.9 102.96,18.73 102.6,19.09 102.6,19.71 102.21,20.09 100.19,20.09 98.7,21.58 98.7,22 98.81,22.11 D35.9 D35.2 98.81,23.68 98.7,23.79 98.7,23.99 98.33,24.37 98.33,24.95 98.44,25.06 U49.52
LAN5_MDI2-_T: length 7.7
  BOTTOM w0.635: U61.16 102.96,7.59 103.2,7.35 103.2,7.22
  BOTTOM w0.762: 103.2,7.22 103.2,5.18 100.87,2.85 POE5.3
LAN5_MDI3+: length 11.7
  BOTTOM w0.089: U49.50 99.44,25.07 99.55,24.96 99.55,24.58 99.92,24.21 99.92,23.67 99.81,23.56 D35.4 D35.7 99.81,22.23 99.92,22.12 99.92,21.86 100.95,20.83 103.83,20.83 105.32,19.34 105.32,19.07 104.96,18.71 U61.11
LAN5_MDI3+_T: length 7.5
  BOTTOM w0.635: U61.14 104.96,7.57 104.74,7.35 104.74,7.2
  BOTTOM w0.762: POE5.2 102.87,3 104.74,4.87 104.74,7.2
LAN5_MDI3-: length 11.7
  BOTTOM w0.089: U61.12 105.96,18.66 105.6,19.02 105.6,19.45 103.94,21.11 101.07,21.11 100.2,21.97 100.2,22.1 100.31,22.21 D35.6 D35.5 100.31,23.56 100.2,23.67 100.2,24.32 99.83,24.7 99.83,24.95 99.94,25.06 U49.49
LAN5_MDI3-_T: length 7.2
  BOTTOM w0.635: 106.2,7.22 106.2,7.35 105.96,7.59 U61.13
  BOTTOM w0.762: POE5.1 104.87,2.91 106.2,4.24 106.2,7.22
LAN5_NVM_CS: length 1.4
  TOP w0.107: v1(89.92,37.21) 89.78,37.07 U50.1
  BOTTOM w0.107: R380.1 v1(89.92,37.21)
LAN5_NVM_SI: length 5.8
  TOP w0.107: R386.2 88.8,31.65 v1(88.77,31.62) 88.28,32.12 U50.5
  BOTTOM w0.107: R387.1 88.27,32.13 v1(88.77,31.62) R377.1
LAN5_NVM_SK: length 3.6
  TOP w0.107: v1(88.77,32.26) 88.77,32.89 88.78,32.89 U50.6
  BOTTOM w0.107: R378.1 v1(88.77,32.26) 88.77,32.89 88.9,33.02 R383.2
LAN5_NVM_SO: length 1.4
  TOP w0.107: v1(89.28,37.21) U50.2
  BOTTOM w0.107: R379.1 89.28,37.21 v1(89.28,37.21)
LAN5_PWR_GOOD: length 1.5
  BOTTOM w0.107: U49.1 91.12,26.22 91.06,26.16 90.55,26.16 90.42,26.29 R371.2
LAN5_VDD0P9_OUT: length 3.9
  TOP w0.508: RZ133.1 102.21,32.21 100.74,32.21 C202.1 100.69,31.88 101.19,31.37 v1(101.6,31.37)
  BOTTOM w0.254: v1(101.6,31.37) 101.45,31.22 U49.38
LAN5_VDD1P5_OUT: length 3.8
  TOP w0.508: RZ140.1 101.22,29.95 C203.1 100.9,30.7 v1(101.6,30.7)
  BOTTOM w0.254: U49.39 101.57,30.72 v1(101.6,30.7)
LAN5_XTAL1: length 5.6
  BOTTOM w0.203: X6.1 102.93,24.95 103.21,25.24 C210.1 103.49,26.31 R382.2 103.3,27.12 101.28,27.12 101.18,27.22 U49.46
LAN5_XTAL2: length 2.9
  BOTTOM w0.203: U49.45 101.22,27.72 101.46,27.48 103.42,27.48 RB18.1
LAN6_ACT#: length 1.7
  BOTTOM w0.107: U51.30 117.23,35.47 R405.2
LAN6_CBOT: length 1.9
  BOTTOM w0.229: C216.2 120.43,31.58 120.18,31.84 119.69,31.84 119.58,31.72 U51.37
LAN6_CT1_A+_V-:
  vias: v1(113.06,10.36) v1(113.06,9.78)
LAN6_CT2_A-_V+:
  vias: v1(117.6,11.28) v1(118.24,11.28)
LAN6_CTOP: length 1.9
  BOTTOM w0.229: U51.40 120.08,30.22
  BOTTOM w0.305: 120.08,30.22 120.35,30.22 C216.1
LAN6_DEV_OFF: length 2.5
  TOP w0.107: R390.1 116.33,34.77 116.2,34.9 v1(116.2,35.38)
  BOTTOM w0.107: R389.2 v1(116.2,35.38) 116.23,35.36 U51.28
LAN6_LINK_100#: length 2.1
  BOTTOM w0.107: U51.31 117.73,35.05 118.64,35.97 R408.2
LAN6_LINK_1000#: length 1.8
  BOTTOM w0.107: R409.2 119.47,33.72 U51.33
LAN6_MDI0+: length 9.6
  BOTTOM w0.089: U62.2 116.15,18.64 116.51,19 116.51,19.09 116.05,19.54 115.2,19.54 113.41,21.34 113.41,22.07 113.3,22.18 D37.10 D37.1 113.3,23.54 113.41,23.65 113.41,24.14 113.84,24.57 113.84,24.94 113.73,25.05 U51.58
LAN6_MDI0+_T: length 9.3
  BOTTOM w0.635: U62.23 116.15,7.6 115.91,7.35 115.91,7.2
  BOTTOM w0.762: POE6.8 110.87,2.92 113.87,5.92 114.73,5.92 115.91,7.09 115.91,7.2
LAN6_MDI0-: length 9.6
  BOTTOM w0.089: U62.3 117.15,18.64 116.79,19 116.79,19.2 116.17,19.82 115.32,19.82 113.69,21.45 113.69,22.05 113.8,22.16 D37.9 D37.2 113.8,23.54 113.69,23.65 113.69,24.03 114.12,24.46 114.12,24.96 114.23,25.07 U51.57
LAN6_MDI0-_T: length 9
  BOTTOM w0.635: 117.37,7.22 117.37,7.35 117.15,7.56 U62.22
  BOTTOM w0.762: 117.37,7.22 117.37,6.7 114.96,4.29 114.25,4.29 112.87,2.91 POE6.7
LAN6_MDI1+: length 11.3
  BOTTOM w0.089: U51.55 115.23,25.03 115.34,24.92 115.34,24.45 114.91,24.02 114.91,23.65 114.8,23.54 D37.4 D37.7 114.8,22.18 114.91,22.07 114.91,21.14 115.4,20.65 116.26,20.65 117.6,19.3 119.42,19.3 119.51,19.22 119.51,19.09 119.15,18.73 U62.5
LAN6_MDI1+_T: length 8.4
  BOTTOM w0.635: U62.20 119.15,7.57 118.93,7.35 118.93,7.2
  BOTTOM w0.762: POE6.6 114.87,2.45 118.93,6.51 118.93,7.2
LAN6_MDI1-: length 11.3
  BOTTOM w0.089: U62.6 120.15,18.69 119.79,19.05 119.79,19.33 119.54,19.58 117.72,19.58 116.37,20.93 115.52,20.93 115.19,21.26 115.19,22.05 115.3,22.16 D37.6 D37.5 115.3,23.56 115.19,23.67 115.19,23.9 115.62,24.33 115.62,24.92 115.73,25.03 U51.54
LAN6_MDI1-_T: length 8.2
  BOTTOM w0.635: U62.19 120.15,7.59 120.39,7.35 120.39,7.22
  BOTTOM w0.762: 120.39,7.22 120.39,6.07 116.87,2.54 POE6.5
LAN6_MDI2+: length 12.2
  BOTTOM w0.089: U62.8 122.15,18.67 122.51,19.03 122.51,19.23 121.47,20.27 118.01,20.27 116.71,21.56 116.71,22.07 116.6,22.18 D39.10 D39.1 116.6,23.51 116.71,23.62 116.71,23.88 116.34,24.25 116.34,25.01 116.23,25.12 U51.53
LAN6_MDI2+_T: length 8
  BOTTOM w0.635: 121.93,7.2 121.93,7.35 122.15,7.57 U62.17
  BOTTOM w0.762: 121.93,7.2 121.93,5.81 118.87,2.74 POE6.4
LAN6_MDI2-: length 12.2
  BOTTOM w0.089: U62.9 123.15,18.66 122.79,19.02 122.79,19.35 121.59,20.55 118.12,20.55 116.99,21.68 116.99,22.07 117.1,22.18 D39.9 D39.2 117.1,23.51 116.99,23.62 116.99,23.99 116.62,24.37 116.62,25.01 116.73,25.12 U51.52
LAN6_MDI2-_T: length 7.7
  BOTTOM w0.635: U62.16 123.15,7.59 123.39,7.35 123.39,7.22
  BOTTOM w0.762: 123.39,7.22 123.39,5.31 120.87,2.78 POE6.3
LAN6_MDI3+: length 13.7
  BOTTOM w0.089: U51.50 117.73,25.07 117.84,24.96 117.84,24.58 118.21,24.21 118.21,23.67 118.1,23.56 D39.4 D39.7 118.1,22.19 118.21,22.08 118.21,21.84 118.82,21.23 123.7,21.23 125.51,19.42 125.51,19.06 125.15,18.7 U62.11
LAN6_MDI3+_T: length 7.5
  BOTTOM w0.635: U62.14 125.15,7.57 124.93,7.35 124.93,7.2
  BOTTOM w0.762: POE6.2 122.87,2.93 124.93,5 124.93,7.2
LAN6_MDI3-: length 13.7
  BOTTOM w0.089: U51.49 118.23,25.09 118.12,24.98 118.12,24.7 118.49,24.32 118.49,23.67 118.6,23.56 D39.5 D39.6 118.6,22.18 118.49,22.07 118.49,21.96 118.94,21.51 123.81,21.51 125.79,19.54 125.79,19.09 126.15,18.73 U62.12
LAN6_MDI3-_T: length 7.3
  BOTTOM w0.635: 126.39,7.22 126.39,7.35 126.15,7.59 U62.13
  BOTTOM w0.762: 126.39,7.22 126.39,4.6 124.87,3.08 POE6.1
LAN6_NVM_CS: length 2
  TOP w0.107: v1(108.21,37.47) 108.21,37.22 108.07,37.07 U52.1
  BOTTOM w0.107: v1(108.21,37.47) 108.2,37.46 R404.1
LAN6_NVM_SI: length 5.8
  TOP w0.107: U52.5 106.56,32.12 v1(107.06,31.62) R410.2
  BOTTOM w0.107: R411.1 106.55,32.13 v1(107.06,31.62) R401.1
LAN6_NVM_SK: length 3.6
  TOP w0.107: v1(107.06,32.26) 107.07,32.26 U52.6
  BOTTOM w0.107: R402.1 v1(107.06,32.26) 107.06,32.89 107.19,33.02 R407.2
LAN6_NVM_SO: length 1.9
  TOP w0.107: U52.2 107.56,37.46 v1(107.57,37.47)
  BOTTOM w0.107: R403.1 v1(107.57,37.47)
LAN6_PWR_GOOD: length 1.5
  BOTTOM w0.107: R395.2 108.71,26.29 108.84,26.16 109.35,26.16 109.41,26.22 U51.1
LAN6_VDD0P9_OUT: length 3.9
  TOP w0.508: v1(119.89,31.37) 119.48,31.37 118.97,31.88 C211.1 119.02,32.21 120.5,32.21 RZ134.1
  BOTTOM w0.229: v1(119.89,31.37) 119.74,31.22 U51.38
LAN6_VDD1P5_OUT: length 3.8
  TOP w0.508: v1(119.89,30.7) 119.19,30.7 C212.1 119.51,29.95 RZ141.1
  BOTTOM w0.229: U51.39 119.86,30.72 v1(119.89,30.7)
LAN6_XTAL1: length 5.6
  BOTTOM w0.203: X7.1 121.5,24.71 C219.1 121.78,26.31 R406.2 121.59,27.12 119.57,27.12 119.46,27.22 U51.46
LAN6_XTAL2: length 2.9
  BOTTOM w0.203: U51.45 119.51,27.72 119.75,27.48 121.7,27.48 RB19.1
LAN7_ACT#: length 1.7
  BOTTOM w0.107: R429.2 135.52,35.85 U53.30
LAN7_CBOT: length 1.9
  BOTTOM w0.229: C225.2 138.81,32.22 137.98,32.22 137.86,32.1 U53.37
LAN7_CT1_A+_V-:
  vias: v1(133.25,10.01) v1(133.27,10.59)
LAN7_CT2_A-_V+:
  vias: v1(137.74,11.25) v1(138.38,11.25)
LAN7_CTOP: length 1.9
  BOTTOM w0.229: 138.37,30.6 U53.40
  BOTTOM w0.305: C225.1 138.64,30.6 138.37,30.6
LAN7_DEV_OFF: length 2.5
  TOP w0.107: v1(134.49,35.76) 134.49,35.28 134.62,35.15 R414.1
  BOTTOM w0.107: U53.28 134.52,35.74 v1(134.49,35.76) R412.2
LAN7_LINK_100#: length 2.1
  BOTTOM w0.107: U53.31 136.02,35.43 136.93,36.35 R432.2
LAN7_LINK_1000#: length 1.8
  BOTTOM w0.107: R433.2 137.76,34.1 U53.33
LAN7_MDI0+: length 11.8
  BOTTOM w0.089: U63.2 136.34,18.64 136.7,19 136.7,19.11 136.51,19.3 133.87,19.3 131.7,21.47 131.7,22.45 131.59,22.56 D42.10 D42.1 131.59,23.94 131.7,24.05 131.7,24.52 132.13,24.95 132.13,25.32 132.02,25.43 U53.58
LAN7_MDI0+_T: length 9.4
  BOTTOM w0.635: U63.23 136.34,7.6 136.1,7.35 136.1,7.2
  BOTTOM w0.762: 136.1,7.2 136.1,7.09 134.92,5.92 134.06,5.92 130.87,2.73 POE7.8
LAN7_MDI0-: length 11.8
  BOTTOM w0.089: U63.3 137.34,18.64 136.98,19 136.98,19.23 136.63,19.58 133.99,19.58 131.98,21.59 131.98,22.46 132.09,22.57 D42.9 D42.2 132.09,23.94 131.98,24.05 131.98,24.41 132.41,24.84 132.41,25.34 132.52,25.45 U53.57
LAN7_MDI0-_T: length 9
  BOTTOM w0.635: U63.22 137.34,7.56 137.56,7.35 137.56,7.22
  BOTTOM w0.762: 137.56,7.22 137.56,6.77 135.08,4.29 134.44,4.29 132.87,2.72 POE7.7
LAN7_MDI1+: length 13
  BOTTOM w0.089: U53.55 133.52,25.41 133.63,25.3 133.63,24.78 133.2,24.35 133.2,24.03 133.09,23.92 D42.4 D42.7 133.09,22.59 133.2,22.48 133.2,22.19 135.19,20.19 136.96,20.19 137.74,19.41 139.55,19.41 139.7,19.25 139.7,19.03 139.34,18.67 U63.5
LAN7_MDI1+_T: length 8.5
  BOTTOM w0.635: U63.20 139.34,7.57 139.13,7.35
  BOTTOM w0.762: 139.13,7.35 139.13,6.59 134.87,2.33 POE7.6
LAN7_MDI1-: length 13
  BOTTOM w0.089: U53.54 134.02,25.41 133.91,25.3 133.91,24.66 133.48,24.23 133.48,24 133.59,23.89 D42.5 D42.6 133.59,22.56 133.48,22.45 133.48,22.3 135.31,20.47 137.07,20.47 137.86,19.68 139.67,19.68 139.98,19.37 139.98,19.04 140.34,18.68 U63.6
LAN7_MDI1-_T: length 8.2
  BOTTOM w0.635: 140.58,7.22 140.58,7.35 140.34,7.59 U63.19
  BOTTOM w0.762: POE7.5 136.87,2.5 140.58,6.22 140.58,7.22
LAN7_MDI2+: length 14.3
  BOTTOM w0.089: U63.8 142.34,18.7 142.7,19.06 142.7,19.27 141.45,20.52 138,20.52 137.45,21.07 135.9,21.07 135,21.97 135,22.44 134.89,22.55 D43.10 D43.1 134.89,23.89 135,24 135,24.26 134.63,24.63 134.63,25.39 134.52,25.5 U53.53
LAN7_MDI2+_T: length 8
  BOTTOM w0.635: 142.13,7.2 142.13,7.35 142.34,7.57 U63.17
  BOTTOM w0.762: POE7.4 138.87,2.55 142.13,5.81 142.13,7.2
LAN7_MDI2-: length 14.3
  BOTTOM w0.089: U63.9 143.34,18.7 142.98,19.06 142.98,19.39 141.57,20.8 138.11,20.8 137.57,21.35 136.02,21.35 135.28,22.09 135.28,22.45 135.39,22.56 D43.9 D43.2 135.39,23.89 135.28,24 135.28,24.37 134.91,24.75 134.91,25.39 135.02,25.5 U53.52
LAN7_MDI2-_T: length 7.8
  BOTTOM w0.635: U63.16 143.34,7.59 143.58,7.35 143.58,7.22
  BOTTOM w0.762: POE7.3 140.87,2.59 143.58,5.31 143.58,7.22
LAN7_MDI3+: length 15.6
  BOTTOM w0.089: U63.11 145.34,18.7 145.7,19.06 145.7,19.17 143.31,21.56 138.46,21.56 138.02,22 136.75,22 136.5,22.25 136.5,22.48 136.39,22.59 D43.7 D43.4 136.39,23.94 136.5,24.05 136.5,24.59 136.13,24.96 136.13,25.34 136.02,25.45 U53.50
LAN7_MDI3+_T: length 7.6
  BOTTOM w0.635: U63.14 145.34,7.57 145.13,7.35 145.13,7.2
  BOTTOM w0.762: 145.13,7.2 145.13,5 142.87,2.74 POE7.2
LAN7_MDI3-: length 15.6
  BOTTOM w0.089: U53.49 136.52,25.47 136.41,25.36 136.41,25.08 136.78,24.7 136.78,24.05 136.89,23.94 D43.5 D43.6 136.89,22.59 136.78,22.48 136.78,22.36 136.87,22.28 138.14,22.28 138.57,21.84 143.42,21.84 145.98,19.28 145.98,19.06 146.34,18.7 U63.12
LAN7_MDI3-_T: length 7.4
  BOTTOM w0.635: U63.13 146.34,7.59 146.58,7.35 146.58,7.22
  BOTTOM w0.762: POE7.1 144.87,2.88 146.58,4.6 146.58,7.22
LAN7_NVM_CS: length 1.7
  TOP w0.107: v1(126.49,37.72) 126.35,37.58 U54.1
  BOTTOM w0.107: R428.1 v1(126.49,37.72)
LAN7_NVM_SI: length 5.8
  TOP w0.107: R434.2 v1(125.35,32) 124.85,32.5 U54.5
  BOTTOM w0.107: R435.1 124.84,32.51 v1(125.35,32) R425.1
LAN7_NVM_SK: length 3.6
  TOP w0.107: v1(125.35,32.64) 125.35,32.64 U54.6
  BOTTOM w0.107: R426.1 v1(125.35,32.64) 125.35,33.27 125.48,33.4 R431.2
LAN7_NVM_SO: length 1.6
  TOP w0.107: v1(125.85,37.72) U54.2
  BOTTOM w0.107: R427.1 125.86,37.71 v1(125.85,37.72)
LAN7_PWR_GOOD: length 1.5
  BOTTOM w0.107: U53.1 127.69,26.6 127.64,26.54 126.89,26.54 R419.2
LAN7_VDD0P9_OUT: length 3.9
  TOP w0.508: v1(138.18,31.75) 137.77,31.75 137.26,32.26 C220.1 137.29,32.56 RZ129.1
  BOTTOM w0.229: U53.38 138.03,31.6 v1(138.18,31.75)
LAN7_VDD1P5_OUT: length 3.8
  TOP w0.508: RZ136.1 137.79,30.33 C221.1 137.48,31.08 v1(138.18,31.08)
  BOTTOM w0.229: U53.39 138.15,31.1 v1(138.18,31.08)
LAN7_XTAL1: length 5.7
  BOTTOM w0.203: X8.1 139.79,25.21 C228.1 140.07,26.7 R430.2 139.88,27.5 137.86,27.5 137.75,27.6 U53.46
LAN7_XTAL2: length 2.9
  BOTTOM w0.203: U53.45 137.79,28.1 138.03,27.86 139.99,27.86 RB20.1
LAN8_ACT#: length 4.6
  BOTTOM w0.107: U55.30 125.57,51.57 125.07,52.07 125.07,54.61 R454.2
LAN8_CBOT: length 1.9
  BOTTOM w0.229: U55.37 129.31,53.92 129.2,54.03 129.2,54.8 C234.2
LAN8_CTOP: length 1.9
  BOTTOM w0.229: 130.81,54.42 U55.40
  BOTTOM w0.305: 130.81,54.42 130.81,54.76 C234.1
LAN8_DEV_OFF: length 2.5
  TOP w0.107: v1(125.66,50.55) 126.14,50.55 126.26,50.67 R438.1
  BOTTOM w0.107: R437.2 v1(125.66,50.55) 125.68,50.57 U55.28
LAN8_LINK_100#: length 4.2
  BOTTOM w0.107: R456.2 126.03,54.48 125.86,54.48 125.35,53.98 125.35,52.7 125.99,52.07 U55.31
LAN8_LINK_1000#: length 3.6
  BOTTOM w0.107: U55.33 127.31,53.81 126.95,54.18 126.95,55.78 R457.2
LAN8_MDI0+: length 7.4
  BOTTOM w0.089: U55.58 135.98,48.07 136.09,48.18 136.41,48.18 136.84,47.75 137.42,47.75 137.53,47.64 D44.1 D44.10 138.8,47.64 138.91,47.75 139.05,47.75 139.24,47.56 139.24,46.3 139.65,45.9 139.95,45.9 140.31,45.54 U64.2
LAN8_MDI0+_T: length 8.6
  BOTTOM w0.089: POE8.8 155.84,42.23 155.2,42.23 151.54,45.9 151.23,45.9 150.87,45.54 U64.23
LAN8_MDI0-: length 7.4
  BOTTOM w0.089: U55.57 135.96,48.57 136.07,48.46 136.53,48.46 136.96,48.03 137.36,48.03 137.47,48.14 D44.2 D44.9 138.8,48.14 138.91,48.03 139.17,48.03 139.52,47.68 139.52,46.42 139.77,46.18 139.93,46.18 140.29,46.54 U64.3
LAN8_MDI0-_T: length 8.6
  BOTTOM w0.089: U64.22 150.87,46.54 151.23,46.18 151.65,46.18 155.32,42.51 155.84,42.51 POE8.7
LAN8_MDI1+: length 6
  BOTTOM w0.089: U64.5 140.26,48.54 139.9,48.9 139.7,48.9 139.34,49.25 138.8,49.25 138.69,49.14 D44.7 D44.4 137.4,49.14 137.29,49.25 136.96,49.25 136.53,49.68 136.12,49.68 136,49.57 U55.55
LAN8_MDI1+_T: length 9.7
  BOTTOM w0.089: POE8.6 156.7,45.92 156.38,46.23 153.74,46.23 153.37,46.61 153.37,48.75 153.22,48.9 151.26,48.9 150.9,48.54 U64.20
LAN8_MDI1-: length 6
  BOTTOM w0.089: U64.6 140.27,49.54 139.91,49.18 139.81,49.18 139.46,49.53 138.79,49.53 138.67,49.64 D44.6 D44.5 137.4,49.64 137.29,49.53 137.07,49.53 136.64,49.96 136.12,49.96 136,50.07 U55.54
LAN8_MDI1-_T: length 9.7
  BOTTOM w0.089: U64.19 150.89,49.54 151.25,49.18 153.34,49.18 153.64,48.87 153.64,46.72 153.86,46.51 156.39,46.51 156.7,46.82 POE8.5
LAN8_MDI2+: length 6.2
  BOTTOM w0.089: U64.8 140.33,51.54 140,51.87 139.87,51.87 139.05,51.05 138.73,51.05 138.62,50.94 D45.10 D45.1 137.3,50.94 137.19,51.05 136.91,51.05 136.53,50.68 136.02,50.68 135.91,50.57 U55.53
LAN8_MDI2+_T: length 9.7
  BOTTOM w0.089: POE8.4 155.84,50.23 155.43,50.23 155.12,50.55 155.12,51.19 arc(155.04,51.38) 154.85,51.46 154.26,51.46 arc(154.08,51.39) 154.01,51.22 154.01,50.98 arc(153.86,50.62) 153.49,50.46 152.91,50.46 arc(152.51,50.63) 152.35,51.02 152.35,51.54 arc(152.24,51.79) 151.99,51.9 151.21,51.9 150.85,51.54 U64.17
LAN8_MDI2-: length 6.2
  BOTTOM w0.089: U55.52 135.91,51.07 136.02,50.96 136.42,50.96 136.79,51.33 137.16,51.33 137.27,51.44 D45.2 D45.9 138.65,51.44 138.76,51.33 138.94,51.33 139.75,52.15 139.95,52.15 140.35,52.54 U64.9
LAN8_MDI2-_T: length 9.7
  BOTTOM w0.089: U64.16 150.87,52.54 151.23,52.18 151.99,52.18 arc(152.44,51.99) 152.63,51.54 152.63,51.02 arc(152.71,50.82) 152.91,50.74 153.49,50.74 arc(153.66,50.81) 153.73,50.98 153.73,51.22 arc(153.89,51.59) 154.26,51.74 154.85,51.74 arc(155.24,51.58) 155.4,51.19 155.4,50.67 155.55,50.51 155.84,50.51 POE8.3
LAN8_MDI3+: length 7.7
  BOTTOM w0.089: U55.50 135.96,52.07 136.08,52.18 136.29,52.18 136.66,52.55 137.16,52.55 137.27,52.44 D45.4 D45.7 138.63,52.44 138.73,52.55 138.99,52.55 139.52,53.09 139.52,54.64 139.79,54.9 140,54.9 140.36,54.54 U64.11
LAN8_MDI3+_T: length 8.2
  BOTTOM w0.089: POE8.2 155.84,54.23 155.03,54.23 arc(154.3,54.54) 154,55.26 154,55.35 arc(153.93,55.51) 153.77,55.58 153.1,55.58 arc(153.05,55.57) 153.01,55.55 arc(152.95,55.5) 152.91,55.45 arc(152.89,55.41) 152.88,55.36 arc(152.69,55.03) 152.33,54.9 151.24,54.9 150.88,54.54 U64.14
LAN8_MDI3-: length 7.7
  BOTTOM w0.089: U64.12 140.33,55.54 139.97,55.18 139.67,55.18 139.24,54.75 139.24,53.2 138.87,52.83 138.76,52.83 138.65,52.94 D45.6 D45.5 137.3,52.94 137.19,52.83 136.54,52.83 136.17,52.46 136.06,52.46 135.95,52.57 U55.49
LAN8_MDI3-_T: length 8.2
  BOTTOM w0.089: U64.13 150.91,55.54 151.27,55.18 152.33,55.18 arc(152.51,55.24) 152.6,55.4 arc(152.63,55.5) 152.67,55.6 arc(152.76,55.7) 152.86,55.79 arc(152.98,55.84) 153.1,55.85 153.77,55.85 arc(154.13,55.71) 154.28,55.35 154.28,55.26 arc(154.5,54.73) 155.03,54.51 155.84,54.51 POE8.1
LAN8_NVM_CS: length 1.4
  TOP w0.107: U56.1 123.96,42.41 v1(123.83,42.55)
  BOTTOM w0.107: R452.1 v1(123.83,42.55)
LAN8_NVM_SI: length 5.8
  TOP w0.107: R458.2 v1(129.41,41.4) 128.92,40.91 U56.5
  BOTTOM w0.107: R449.1 v1(129.41,41.4) 128.91,40.89 R459.1
LAN8_NVM_SK: length 3.6
  TOP w0.107: U56.6 128.77,41.41 v1(128.78,41.4)
  BOTTOM w0.107: R455.2 128.02,41.53 128.14,41.4 v1(128.78,41.4) R450.1
LAN8_NVM_SO: length 1.4
  TOP w0.107: U56.2 v1(123.83,41.91)
  BOTTOM w0.107: R451.1 123.83,41.91 v1(123.83,41.91)
LAN8_PWR_GOOD: length 1.5
  BOTTOM w0.107: U55.1 134.81,43.75 134.87,43.69 134.87,42.94 R443.2
LAN8_VDD0P9_OUT: length 3.7
  TOP w0.508: v1(129.67,54.23) 129.67,54.15 128.91,53.39 C229.1 128.88,53.34 RZ105.1
  BOTTOM w0.229: U55.38 129.81,54.08 v1(129.67,54.23)
LAN8_VDD1P5_OUT: length 3.6
  TOP w0.508: RZ104.1 131.09,53.91 C230.1 130.34,53.68 v1(130.34,54.23)
  BOTTOM w0.229: U55.39 130.31,54.2 v1(130.34,54.23)
LAN8_XTAL1: length 5.2
  BOTTOM w0.203: X9.1 134.89,57.16 134.86,57.14 C237.1 134.75,56.48 134.75,55.2 134.53,54.98 R453.2 134.37,54.97 133.91,54.52 133.91,53.89 133.81,53.8 U55.46
LAN8_XTAL2: length 1.8
  BOTTOM w0.203: RB21.1 133.58,54.83 133.58,54.03 133.31,53.76 U55.45
LAN_CLKN1: length 98.8
  BOTTOM w0.114: U41.25 24.81,37.82 24.93,37.94 24.93,39.58 27.32,41.97 34.04,41.97 45.42,53.34 45.42,59.74 47.42,61.75 49.04,61.75 58.11,70.82 59.94,70.82 66.34,77.22 70.48,77.22 75.39,82.12 75.39,91.44 75.01,91.82 75.01,94.64 74.87,94.78 74.87,95.12 75.01,95.26 75.01,95.6 74.87,95.74 74.87,96.08 75.01,96.22 75.01,97.1 76.15,98.25 76.15,98.45 76.4,98.69 76.59,98.69 76.83,98.93 76.83,99.12 77.08,99.37 77.27,99.37 78.2,100.3 78.2,102.64 77.28,103.57 76.87,103.57 RZ184.2
LAN_CLKN2: length 87.8
  TOP w0.114: RZ50.2 76.43,101.4 76.67,101.16 76.92,101.16 77.19,100.89 77.19,100.21 78.16,99.24 78.8,99.24 v1(79.03,99.47)
  BOTTOM w0.114: U43.25 41.58,34.89 41.7,35.01 41.7,40.51 44.27,43.08 44.27,47.8 51.08,54.61 51.08,59.06 51.81,59.79 52.32,59.79 59.66,67.13 62.33,67.13 67.32,72.12 68.69,72.12 70.99,74.42 70.99,76.31 76.39,81.71 76.39,91.88 76.01,92.26 76.01,96.69 78.56,99.24 78.8,99.24 v1(79.03,99.47)
LAN_CLKN3: length 83.4
  TOP w0.114: RZ48.2 76.87,103.19 78.77,103.19 v1(78.99,102.96)
  BOTTOM w0.114: U45.25 59.86,34.89 59.99,35.01 59.99,39.96 58.93,41.02 58.93,46.49 60.3,47.86 60.3,53.67 65,58.37 65,60.1 65.68,60.78 67.41,60.78 68.47,61.84 68.47,65.54 70.31,67.39 70.31,71.56 72.39,73.64 72.39,75.97 74.45,78.03 75.54,78.03 77.39,79.88 77.39,93.12 77.26,93.25 77.26,93.6 77.39,93.73 77.39,94.08 77.26,94.21 77.26,94.56 77.39,94.7 77.39,95.95 79.71,98.26 79.71,99.9 79.57,100.04 79.57,100.38 79.71,100.52 79.71,100.86 79.57,101 79.57,101.34 79.71,101.48 79.71,102.92 79.43,103.19 79.22,103.19 v1(78.99,102.96)
LAN_CLKN4: length 81.4
  TOP w0.114: v1(77.66,100.93) 77.9,101.17 80.42,101.17 v1(80.64,100.94)
  BOTTOM w0.114: U47.25 78.15,34.89 78.27,35.01 78.27,38.49 76.23,40.54 74.24,40.54 72.07,42.71 72.07,47.41 71.32,48.16 71.32,59.59 72.05,60.31 72.05,62.34 71.5,62.89 71.5,70.57 74.37,73.44 74.37,76.12 75.11,76.86 75.79,76.86 78.4,79.46 78.4,83.96 78.59,84.15 78.59,93.17 78.45,93.31 78.45,93.65 78.59,93.79 78.59,94.13 78.45,94.27 78.45,94.61 78.59,94.75 78.59,95.62 81.26,98.29 81.26,98.86 81.12,99 81.12,99.34 81.26,99.48 81.26,99.82 81.12,99.96 81.12,100.3 81.26,100.44 81.26,100.9 81,101.17 80.87,101.17 v1(80.64,100.94) ; RZ186.2 76.87,101.16 77.43,101.16 v1(77.66,100.93)
LAN_CLKN5: length 87.1
  TOP w0.114: v1(81.76,97.03) 81.53,96.8 79.17,96.8 77.1,98.87 76.87,98.87 RZ54.2
  BOTTOM w0.114: v1(81.76,97.03) 81.53,96.8 81.24,96.8 79.6,95.16 79.6,83.6 79.4,83.39 79.4,79.02 76.25,75.87 76.25,75.44 75.39,74.58 75.39,72.57 74.73,71.91 74.73,70.16 73.48,68.91 73.48,63.42 76.08,60.82 76.08,59.76 77.29,58.55 78.69,58.55 79.07,58.17 82.85,58.17 83.59,57.43 86.82,57.43 92.7,51.55 92.7,43.34 96.56,39.48 96.56,35.01 96.44,34.89 U49.25
LAN_CLKN6: length 114.5
  TOP w0.114: v1(72.92,43.18) 73.15,42.95 73.15,42.79 72.98,42.62 72.47,42.62 72.33,42.76 71.99,42.76 71.85,42.62 71.51,42.62 71.37,42.76 71.03,42.76 70.89,42.62 70.55,42.62 70.41,42.76 70.07,42.76 69.93,42.62 41.94,42.62 38.5,46.06 38.5,46.26 38.25,46.5 38.06,46.5 37.82,46.74 37.82,46.93 37.57,47.18 37.38,47.18 37.14,47.42 37.14,47.61 36.89,47.86 36.7,47.86 34.92,49.63 34.92,59.42 35.06,59.55 35.06,59.9 34.92,60.03 34.92,60.38 35.06,60.51 35.06,60.86 34.92,60.99 34.92,61.34 35.06,61.47 35.06,61.82 34.92,61.95 34.92,64.14 35.84,65.05 36.04,65.05 36.28,65.3 36.28,65.49 36.52,65.73 36.72,65.73 36.96,65.98 36.96,66.17 37.27,66.48 39.46,66.48 RZ87.2
  IN1 w0.122: v1(114.62,38.99) 114.85,39.22 114.85,39.83 114.45,40.23 108.92,40.23 107.67,38.99 100.12,38.99 98.6,40.51 88.57,40.51 87,42.08 78.59,42.08 77.81,41.3 74.16,41.3 73.15,42.31 73.15,42.95 v1(72.92,43.18)
  BOTTOM w0.114: U51.25 114.73,34.89 114.85,35.01 114.85,38.76 v1(114.62,38.99)
LAN_CLKN7: length 134.8
  TOP w0.114: RZ93.2 43.01,65.21 37.78,65.21 37.52,64.95 37.52,64.76 37.27,64.51 37.08,64.51 36.82,64.26 36.82,64.06 36.57,63.81 36.38,63.81 36.07,63.5 36.07,62.34 36.21,62.2 36.21,61.85 36.07,61.71 36.07,61.36 36.21,61.22 36.21,60.86 36.07,60.73 36.07,51.26 41.27,46.05 41.27,45.31 v1(41.5,45.09)
  IN1 w0.122: v1(132.91,38.35) 133.14,38.13 133.14,36.47 132.86,36.19 132.67,36.19 132.42,35.93 132.42,35.75 132.16,35.49 131.97,35.49 131.72,35.23 131.72,35.05 131.21,34.54 115.01,34.54 114.12,33.66 101.6,33.66 100.71,32.77 96.52,32.77 95.63,33.66 86.85,33.66 83.72,36.78 60.65,36.78 56.34,41.09 56.34,41.27 56.09,41.53 55.9,41.53 55.64,41.79 55.64,41.97 55.39,42.23 55.2,42.23 54.94,42.49 54.94,42.67 54.68,42.93 54.5,42.93 53.46,43.97 45.96,43.97 45.83,44.1 45.46,44.1 45.33,43.97 44.97,43.97 44.84,44.1 44.47,44.1 44.34,43.97 43.98,43.97 43.85,44.1 43.48,44.1 43.35,43.97 41.75,43.97 41.27,44.44 41.27,44.86 v1(41.5,45.09)
  BOTTOM w0.114: v1(132.91,38.35) 133.14,38.13 133.14,35.37 133.02,35.25 U53.25
LAN_CLKN8: length 102
  TOP w0.114: RZ94.2 39.46,63.94 38.87,63.94 v1(38.65,63.72)
  IN1 w0.122: v1(123.32,49.3) 123.09,49.53 121.06,49.53 119.35,47.83 108.66,47.83 107.37,49.12 94.11,49.12 91.73,51.5 87.16,51.5 85.34,49.68 80.95,49.68 79.41,51.22 72.5,51.22 66.91,56.81 61.86,56.81 59.21,59.46 59.21,62.12 57.35,63.98 42.72,63.98 41.41,65.29 39.51,65.29 39.37,65.15 39.37,64.16 39.15,63.94 38.87,63.94 v1(38.65,63.72)
  BOTTOM w0.114: v1(123.32,49.3) 123.55,49.53 125.12,49.53 125.45,49.19 125.93,49.19 126.06,49.07 U55.25
LAN_CLKP1: length 98.8
  BOTTOM w0.114: RZ183.2 76.87,103.82 77.38,103.82 78.45,102.75 78.45,100.19 75.26,97 75.26,91.93 75.64,91.55 75.64,82.02 70.59,76.96 66.45,76.96 60.05,70.56 58.22,70.56 49.15,61.49 47.53,61.49 45.67,59.64 45.67,53.24 34.14,41.71 27.42,41.71 25.19,39.48 25.19,37.96 25.31,37.83 U41.26
LAN_CLKP2: length 87.8
  TOP w0.114: RZ52.2 76.43,100.66 76.67,100.9 76.82,100.9 76.94,100.78 76.94,100.1 78.05,98.98 78.8,98.98 v1(79.03,98.76)
  BOTTOM w0.114: U43.26 42.08,34.89 41.95,35.01 41.95,40.4 44.53,42.98 44.53,47.7 51.33,54.5 51.33,58.95 51.92,59.54 52.43,59.54 59.77,66.88 62.44,66.88 67.43,71.87 68.8,71.87 71.25,74.32 71.25,76.2 76.64,81.6 76.64,91.99 76.26,92.37 76.26,93.27 76.4,93.41 76.4,93.75 76.26,93.89 76.26,94.23 76.4,94.37 76.4,94.71 76.26,94.85 76.26,96.58 77.08,97.4 77.27,97.4 77.52,97.64 77.52,97.84 77.76,98.08 77.95,98.08 78.2,98.32 78.2,98.52 78.66,98.98 78.8,98.98 v1(79.03,98.76)
LAN_CLKP3: length 83.3
  TOP w0.114: RZ42.2 76.87,103.44 78.77,103.44 v1(78.99,103.67)
  BOTTOM w0.114: v1(78.99,103.67) 79.22,103.44 79.54,103.44 79.96,103.02 79.96,98.16 77.65,95.85 77.65,79.78 75.65,77.77 74.55,77.77 72.64,75.87 72.64,73.53 70.56,71.45 70.56,67.28 68.72,65.44 68.72,61.73 67.51,60.53 65.79,60.53 65.25,60 65.25,58.27 60.55,53.57 60.55,47.76 59.18,46.39 59.18,41.13 60.24,40.07 60.24,35.01 60.36,34.89 U45.26
LAN_CLKP4: length 81.4
  TOP w0.114: v1(80.64,101.65) 80.42,101.42 77.88,101.42 v1(77.66,101.64)
  BOTTOM w0.114: v1(77.66,101.64) 77.43,101.41 76.87,101.41 RZ185.2 ; v1(80.64,101.65) 80.87,101.42 81.1,101.42 81.51,101.01 81.51,98.19 78.84,95.51 78.84,84.05 78.65,83.86 78.65,79.36 75.9,76.61 75.21,76.61 74.63,76.02 74.63,73.33 71.75,70.46 71.75,63 72.3,62.45 72.3,60.21 71.58,59.48 71.58,48.26 72.33,47.51 72.33,42.82 74.35,40.79 76.33,40.79 78.53,38.59 78.53,35.01 78.65,34.89 U47.26
LAN_CLKP5: length 87.1
  TOP w0.114: v1(81.76,96.32) 81.53,96.55 79.07,96.55 77,98.62 76.87,98.62 RZ55.2
  BOTTOM w0.114: v1(81.76,96.32) 81.54,96.54 81.35,96.54 79.86,95.05 79.86,88.4 79.99,88.26 79.99,87.92 79.86,87.78 79.86,87.44 79.99,87.3 79.99,86.96 79.86,86.82 79.86,86.48 79.99,86.34 79.99,86 79.86,85.86 79.86,83.49 79.65,83.29 79.65,80.57 79.79,80.44 79.79,80.09 79.65,79.96 79.65,78.92 76.5,75.77 76.5,75.34 75.64,74.47 75.64,72.47 74.98,71.81 74.98,70.05 73.74,68.81 73.74,63.53 76.34,60.92 76.34,59.86 77.4,58.8 78.79,58.8 79.17,58.42 82.96,58.42 83.7,57.68 86.92,57.68 92.95,51.65 92.95,43.45 96.82,39.58 96.82,35.01 96.94,34.89 U49.26
LAN_CLKP6: length 114.5
  TOP w0.114: v1(73.63,43.18) 73.41,42.95 73.41,42.68 73.09,42.37 41.83,42.37 34.67,49.53 34.67,64.24 37.17,66.74 39.46,66.74 RZ84.2
  IN1 w0.122: v1(73.63,43.18) 73.41,42.95 73.41,42.42 74.27,41.55 77.71,41.55 78.49,42.34 87.1,42.34 88.67,40.77 98.7,40.77 100.23,39.24 107.57,39.24 108.81,40.49 114.55,40.49 115.1,39.94 115.1,39.22 v1(115.33,38.99)
  BOTTOM w0.114: U51.26 115.23,34.89 115.1,35.01 115.1,38.76 v1(115.33,38.99)
LAN_CLKP7: length 134.8
  TOP w0.114: v1(40.79,45.09) 41.02,45.31 41.02,45.94 35.81,51.15 35.81,63.61 37.68,65.47 43.01,65.47 RZ88.2
  IN1 w0.122: v1(133.62,38.35) 133.39,38.13 133.39,36.37 131.32,34.29 115.11,34.29 114.22,33.4 101.71,33.4 100.82,32.51 96.41,32.51 95.53,33.4 86.74,33.4 83.62,36.53 60.55,36.53 53.36,43.71 41.65,43.71 41.02,44.34 41.02,44.86 v1(40.79,45.09)
  BOTTOM w0.114: v1(133.62,38.35) 133.39,38.13 133.39,35.39 133.52,35.27 U53.26
LAN_CLKP8: length 102
  TOP w0.114: RZ92.2 39.46,64.2 38.87,64.2 v1(38.65,64.43)
  IN1 w0.122: v1(123.32,50.01) 123.09,49.78 120.95,49.78 119.25,48.08 108.77,48.08 107.47,49.38 94.21,49.38 91.83,51.76 87.06,51.76 85.24,49.94 81.06,49.94 79.52,51.48 72.6,51.48 67.02,57.06 61.96,57.06 59.46,59.56 59.46,62.23 57.45,64.24 42.82,64.24 41.52,65.54 39.4,65.54 39.12,65.26 39.12,64.27 39.05,64.2 38.87,64.2 v1(38.65,64.43)
  BOTTOM w0.114: v1(123.32,50.01) 123.55,49.78 125.22,49.78 125.56,49.45 125.98,49.45 126.1,49.57 U55.26
LAN_GND:
  vias: v1(0.74,13.84) v1(0.74,11.3) v1(0.74,8.76) v1(0.74,6.22) v1(0.74,3.68) v1(0.74,1.14) v1(1.73,9.98) v1(1.73,5.92) v1(1.85,14.05) v1(2.49,9.98) v1(2.49,5.92) v1(2.62,14.05) v1(3.24,0.74) v1(3.38,14.05) v1(3.38,9.98) v1(3.38,5.92) v1(5.78,0.74) v1(8.32,0.74) v1(10.86,0.74) v1(13.4,0.74) v1(15.94,0.74) v1(18.48,0.74) v1(21.02,0.74) v1(23.56,0.74) v1(26.21,11.33) v1(26.8,11.33) v1(28.64,0.74) v1(28.91,5.92) v1(29.54,5.92) v1(30.18,5.92) v1(30.81,5.92) v1(31.18,0.74) v1(33.72,0.74) v1(36.26,0.74) v1(38.8,0.74) v1(41.34,0.74) v1(43.88,0.74) v1(49.02,5.84) v1(48.96,0.74) v1(49.78,5.84) v1(50.55,5.84) v1(51.31,5.84) v1(51.5,0.74) v1(54.04,0.74) v1(56.58,0.74) v1(59.12,0.74) v1(61.66,0.74) v1(64.2,0.74) v1(69.22,5.84) v1(69.28,0.74) v1(69.98,5.84) v1(70.74,5.84) v1(71.5,5.84) v1(71.82,0.74) v1(74.36,0.74) v1(76.9,0.74) v1(79.44,0.74) v1(81.98,0.74) v1(84.52,0.74) v1(89.41,5.84) v1(89.6,0.74) v1(90.17,5.84) v1(90.93,5.84) v1(91.69,5.84) v1(92.14,0.74) v1(94.68,0.74) v1(97.22,0.74) v1(99.76,0.74) v1(102.3,0.74) v1(104.84,0.74) v1(107.38,0.74) v1(109.6,5.84) v1(109.92,0.74) v1(110.36,5.84) v1(111.12,5.84) v1(111.89,5.84) v1(112.46,0.74) v1(115,0.74) v1(117.54,0.74) v1(120.08,0.74) v1(122.62,0.74) v1(125.16,0.74) v1(127.7,0.74) v1(129.79,5.84) v1(130.24,0.74) v1(130.56,5.84) v1(131.32,5.84) v1(132.08,5.84) v1(132.78,0.74) v1(135.32,0.74) v1(137.86,0.74) v1(140.4,0.74) v1(142.94,0.74) v1(145.8,60.07) v1(145.8,54.99) v1(145.8,49.91) v1(146.43,49.91) v1(146.56,60.07) v1(146.56,54.99) v1(147.45,45.85) v1(147.45,45.21) v1(148.02,0.74) v1(148.36,60.33) v1(149.12,60.33) v1(150.56,0.74) v1(152.35,50.11) v1(152.43,53.82) v1(152.43,53.01) v1(152.4,47.5) v1(152.37,46.86) v1(153.1,0.74) v1(155.64,0.74) v1(158.18,0.74) v1(159.26,53.84) v1(159.26,51.3) v1(159.26,48.76) v1(159.26,46.22) v1(159.26,43.68) v1(159.26,41.14) v1(159.26,38.6) v1(159.26,36.06) v1(159.26,33.52) v1(159.26,30.98) v1(159.26,28.44) v1(159.26,25.9) v1(159.26,23.36) v1(159.26,20.82) v1(159.26,18.28) v1(159.26,15.74) v1(159.26,13.2) v1(159.26,10.66) v1(159.26,8.12) v1(159.26,5.58) v1(159.26,3.04)
