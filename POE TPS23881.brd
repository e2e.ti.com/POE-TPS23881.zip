# Allegro board POE TPS23881.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXP2: length 64.8
  IN1 w0.122: v1(67.59,81.98) 67.82,81.75 67.82,80.41 68.4,79.83 68.4,74.62 68.67,74.35 69.17,74.35 v1(69.33,74.19)
  BOTTOM w0.114: U43.24 41.08,34.87 40.93,35.02 40.93,40.82 43.48,43.38 43.48,48.08 50.19,54.78 50.19,59.26 51.54,60.6 51.79,60.6 59.08,67.89 60.38,67.89 61.02,68.53 61.21,68.53 61.46,68.78 61.46,68.98 62.26,69.77 63.5,69.77 65.1,71.37 65.29,71.37 65.54,71.62 65.54,71.81 65.79,72.06 65.99,72.06 66.24,72.32 66.24,72.51 66.63,72.9 68.17,72.9 68.86,73.58 68.86,74.35 68.94,74.42 69.1,74.42 v1(69.33,74.19) ; v1(67.59,81.98) 67.82,82.21 67.82,82.46 CM78.2
PCIE_TXP3: length 63.6
  IN1 w0.122: v1(68.43,67.44) 68.2,67.67 68.2,69.24 67.64,69.8 67.64,71.67 67.45,71.86 67.45,71.86 64.97,74.34 64.97,76.81 61.72,80.06 61.72,81.88 v1(61.95,82.11)
  BOTTOM w0.114: v1(61.95,82.11) 61.72,82.33 61.72,82.59 CM73.2 ; U45.24 59.36,34.87 59.24,34.99 59.24,35.5 59.05,35.69 59.05,39.6 58.17,40.49 58.17,46.79 59.55,48.17 59.55,54.11 63.77,58.33 63.77,61.29 64.25,61.77 67.11,61.77 arc(67.47,61.92) 67.61,62.28 67.61,63.2 arc(67.48,63.53) 67.14,63.67 64.68,63.67 arc(64.47,63.75) 64.39,63.96 64.39,64.77 arc(64.47,64.97) 64.67,65.05 66.76,65.05 68.2,66.49 68.2,67.21 v1(68.43,67.44)
PCIE_TXP4: length 61.9
  IN1 w0.122: v1(58.72,82.11) 58.5,81.88 58.5,81.36 59.01,80.84 59.01,76.98 64.21,71.78 64.21,70.84 arc(64.28,70.68) 64.44,70.61 64.7,70.61 arc(65.04,70.47) 65.18,70.13 65.18,69.67 arc(65.01,69.26) 64.6,69.09 64.42,69.09 arc(64.27,69.03) 64.21,68.88 64.21,65.53 67.01,62.74 70.66,62.74 71.12,62.28 71.12,61.57 v1(71.35,61.34)
  BOTTOM w0.114: U47.24 77.65,34.87 77.53,34.99 77.53,35.5 77.34,35.69 77.34,38.08 75.67,39.75 73.86,39.75 71.23,42.38 71.23,47.11 70.56,47.78 70.56,60.12 71.12,60.68 71.12,61.11 v1(71.35,61.34) ; v1(58.72,82.11) 58.5,82.33 58.5,82.59 CM75.2
PCIE_TXP5: length 75.6
  TOP w0.114: v1(56.54,82.11) 56.31,82.33 56.31,82.59 CM49.2
  IN1 w0.122: v1(56.54,82.11) 56.31,81.88 56.31,81.3 56.51,81.1 57.63,81.1 58.23,80.5 58.23,76.65 62.13,72.75 62.13,70.64 63.32,69.44 63.32,65.05 66.65,61.72 69.09,61.72 70.1,60.71 74.3,60.71 74.8,60.2 74.8,59.41 v1(75.03,59.18)
  BOTTOM w0.114: v1(75.03,59.18) 74.8,58.95 74.8,58.68 76.08,57.4 82.55,57.4 83.29,56.67 86.5,56.67 91.95,51.22 91.95,43.03 95.63,39.34 95.63,35.41 95.82,35.22 95.82,34.99 95.94,34.87 U49.24
PCIE_TXP6: length 76.5
  TOP w0.114: CM60.2 55.87,54.53 55.87,54.25 v1(55.64,54.03)
  IN1 w0.122: v1(55.64,54.03) 55.87,53.8 55.87,50.15 56.18,49.83 56.18,44.65 59.94,40.9 72.25,40.9 73.42,39.73 87.08,39.73 88.75,38.06 98.61,38.06 99.95,36.73 113.55,36.73 113.92,37.1 113.92,37.74 v1(114.15,37.97)
  BOTTOM w0.114: v1(114.15,37.97) 113.92,37.74 113.92,35.43 114.1,35.25 114.1,34.99 114.23,34.87 U51.24
PCIE_TXP7: length 96.4
  TOP w0.114: CM62.2 54.6,51.49 54.6,51.21 v1(54.37,50.98)
  IN1 w0.122: v1(54.37,50.98) 54.6,50.75 54.6,50.12 55.27,49.45 55.27,44.45 59.61,40.11 71.93,40.11 73.1,38.94 80.59,38.94 81.17,38.35 84.96,38.35 87.5,35.81 113.79,35.81 114.8,36.82 121.91,36.82 124.59,39.5 131.94,39.5 132.21,39.77 132.21,40.05 v1(132.44,40.27)
  BOTTOM w0.114: v1(132.44,40.27) 132.21,40.05 132.21,36.07 132.39,35.88 132.39,35.37 132.52,35.25 U53.24
PCIE_TXP8: length 98
  TOP w0.114: v1(42.21,63.23) 42.44,63 43.1,63 CM58.2
  IN1 w0.122: v1(125.01,48.8) 124.79,48.57 121.22,48.57 119.91,47.26 107.88,47.26 107.45,47.7 94.75,47.7 91.47,50.97 87.38,50.97 85.56,49.15 78.45,49.15 77.85,49.75 76.91,50.69 72.28,50.69 66.69,56.28 61.6,56.28 58.65,59.23 58.65,60.88 58.28,61.25 49.32,61.25 47.93,59.87 43.92,59.87 42.93,60.86 42.93,62.8 42.72,63 42.44,63 v1(42.21,63.23)
  BOTTOM w0.114: v1(125.01,48.8) 125.24,48.57 125.67,48.57 125.8,48.45 126.04,48.45 126.17,48.57 U55.24
PCIE_WAKE#: length 227
  TOP w0.107: Q50.D 99.69,106.43 99.24,105.97 R2.1 99.21,105.77 99.21,103.38 99.35,103.24 Q3.G 100.36,102.54 v1(100.41,102.49)
  IN1 w0.124: v1(19.56,38.23) 19.56,37.97 20.45,37.08 29.84,37.08 30.86,36.07 35.56,36.07 v1(36.32,35.31) 37.47,34.16 50.29,34.16 51.69,35.56 54.36,35.56 v1(54.61,35.31) 55.75,34.16 67.18,34.16 68.58,35.56 72.9,35.56 v1(73.15,35.31)
  IN3 w0.124: v1(73.15,35.31) 73.91,36.07 90.42,36.07 v1(91.19,35.31) 91.74,35.86 95.94,35.86 96.38,36.3 108.48,36.3 v1(109.47,35.31) 110.72,36.55 121.79,36.55 123.37,34.97 127.15,34.97 127.76,35.58 v1(127.76,35.61) 127.76,36.22 127.08,36.91 127.08,42.75 126.01,43.81 v1(125.86,43.81)
  BOTTOM w0.107: U51.16 109.58,33.72 109.47,33.83 v1(109.47,35.31) R394.1 109.32,35.97 108.71,36.58 108.71,40.39 111.12,42.8 111.12,48.97 110.1,50 110.1,56.17 111.32,57.39 111.32,60.36 112.75,61.8 112.75,76.76 107.21,82.3 107.21,91.31 106.37,92.16 106.37,99.37 104.25,101.49 102.47,101.49 101.47,102.49 v1(100.41,102.49) ; U53.16 127.87,34.1 127.76,34.21 v1(127.76,35.61) R418.1 ; R298.1 v1(36.32,35.31) 36.32,33.83 36.43,33.72 U43.16 ; R370.1 v1(91.19,35.31) 91.19,33.91 91.37,33.72 U49.16 ; U45.16 54.72,33.72 54.61,33.83 v1(54.61,35.31) R322.1 ; R274.1 v1(19.56,38.23) 19.56,36.75 19.66,36.64 U41.16 ; U47.16 73.08,33.72 72.9,33.9 72.9,35.05 v1(73.15,35.31) 72.9,35.56 R346.1 ; R442.1 v1(125.86,43.81) 127.21,43.81 127.31,43.92 U55.16
PCIE_WAKE_N: length 96
  TOP w0.107: v1(56.25,118.52) 56.25,118.11 J1.A8
  BOTTOM w0.107: RZ178.2 146.46,112.5 143.62,112.5 140.61,111.5 138.64,109.86 137.63,109.84 137.25,109.84 135.42,109.8 134.27,110.32 125.22,110.32 124.62,110.93 106.81,110.93 104.57,108.69 98.28,108.69 96.47,110.5 85.59,110.5 79.23,112.99 78.08,113.29 73.55,113.29 57.55,116.69 56.25,117.99 v1(56.25,118.52)
PGANG: length 2.6
  TOP w0.107: R166.2 R168.1 87.93,63.92 87.3,64.55 U20.5
PLTRST#_TPM: length 2.3
  TOP w0.107: U18.17 111.82,89.09 112.56,89.82 U19.4
POE_56: length 9.7
  TOP w0.254: RZ26.1 22.71,116.69 26.67,116.69 26.95,116.97 27.25,116.97 v1(27.46,116.76) ; U83.20 18.84,115.4 19.06,115.18
  TOP w0.508: 21.11,114.17 21.08,114.15 C460.2 19.06,115.18
  BOTTOM w0.254: v1(27.46,116.76) 27.51,116.71 R730.2
  vias: v2(18.36,104.09) v2(18.36,103.33) v2(18.36,102.57) v2(18.36,101.8) v2(18.36,101.04) v2(19.13,104.09) v2(19.13,103.33) v2(19.13,102.57) v2(19.13,101.8) v2(19.13,101.04) v2(22.17,112.85) v2(22.17,111.96) v2(22.17,110.95) v2(22.17,106.12) v2(22.17,105.23) v2(22.17,102.31) v2(22.17,101.42) v2(22.94,112.85) v2(22.94,111.96) v2(22.94,110.95) v2(22.94,106.12) v2(22.94,105.23) v2(22.94,102.31) v2(22.94,101.42) v2(23.7,112.85) v2(23.7,111.96) v2(23.7,110.95) v2(23.7,106.12) v2(23.7,105.23) v2(23.7,102.31) v2(23.7,101.42) v2(24.46,112.85) v2(24.46,111.96) v2(24.46,110.95) v2(24.46,106.12) v2(24.46,105.23) v2(24.46,102.31) v2(24.46,101.42) v2(25.22,112.85) v2(25.22,111.96) v2(25.22,110.95) v2(25.22,106.12) v2(25.22,105.23) v2(25.22,102.31) v2(25.22,101.42)
POE_EN: length 179.2
  TOP w0.254: RZ78.2 v1(115.47,70.46) ; Q69.2 v1(5.61,80.66) ; R740.1 v1(11.1,108.28)
  TOP w0.279: U83.4 10.94,108.44 v1(11.1,108.28)
  IN3 w0.254: 6.22,83.67 5.61,83.06 v1(5.61,80.66) ; 6.22,83.67 21.89,83.67 22.42,83.13 35.18,83.13 37.62,80.7 37.62,73.05 46.76,63.91 46.76,60.2 47.27,59.69 49.68,59.69 51.21,58.17 69.48,58.17 71.78,55.87 75.28,55.87 76.06,55.09 82.45,55.09 83.37,56.01 85.94,56.01 86.67,56.73 91.94,56.73 97.05,61.85 104.84,61.85 108.22,65.23 108.22,69.96 110.34,72.09 112.19,72.09 113.82,70.46 v1(115.47,70.46) ; 6.22,83.67 5.61,84.28 5.61,97.05 6.17,97.61 12.01,97.61 12.52,98.12 12.52,107.26 12.27,107.52 11.86,107.52 v1(11.1,108.28)
  BOTTOM w0.254: v1(11.1,108.28) 11,108.38 C471.2 9.99,109.33 R742.2
POE_EN#: length 7.5
  TOP w0.107: 119.76,68.69 120.89,68.69 RB55.1 121.59,68.86 122.2,69.47 122.2,72.57 123.1,73.46 U14.8
POE_FAST_SHUTDOWN: length 2
  TOP w0.229: RZ62.1 11.26,79.57 U65.56
POE_GATE:
  vias: v2(7.32,88.98) v2(7.32,88.21) v2(7.32,87.45) v2(7.32,86.69) v2(7.32,85.93) v2(8.08,88.98) v2(8.08,88.21) v2(8.08,87.45) v2(8.08,86.69) v2(8.08,85.93) v2(8.84,88.98) v2(8.84,88.21) v2(8.84,87.45) v2(8.84,86.69) v2(8.84,85.93) v2(9.6,88.98) v2(9.6,88.21) v2(9.6,87.45) v2(9.6,86.69) v2(9.6,85.93) v2(10.36,88.98) v2(10.36,88.21) v2(10.36,87.45) v2(10.36,86.69) v2(10.36,85.93)
POE_IN: length 18.9
  TOP w0.508: DC_IN1.3 7.69,177.32 ; DC_IN1.3 7.69,174.8 ; DC_IN1.3 8.95,176.06 ; DC_IN1.3 6.43,176.06
  IN2 w0.508: DC_IN1.3 8.95,176.06 ; DC_IN1.3 7.69,174.8 ; DC_IN1.3 6.43,176.06 ; DC_IN1.3 7.69,177.32
  IN3 w0.762: 7.69,174.8 DC_IN1.3 ; DC_IN1.3 8.95,176.06 ; DC_IN1.3 6.43,176.06 ; DC_IN1.3 7.69,177.32
  BOTTOM w0.508: DC_IN1.3 8.95,176.06 ; DC_IN1.3 7.69,177.32 ; DC_IN1.3 7.69,174.8
  vias: v2(3.51,163.4) v2(3.51,162.51) v2(3.51,159.59) v2(3.51,158.7) v2(3.63,104.09) v2(3.63,103.33) v2(3.63,102.57) v2(3.63,101.8) v2(3.63,101.04) v2(4.39,163.4) v2(4.39,162.51) v2(4.39,159.59) v2(4.39,158.7) v2(4.52,104.09) v2(4.52,103.33) v2(4.52,102.57) v2(4.52,101.8) v2(4.52,101.04) v2(5.28,163.4) v2(5.28,162.51) v2(5.28,159.59) v2(5.28,158.7) v2(5.28,104.09) v2(5.28,103.33) v2(5.28,102.57) v2(5.28,101.8) v2(5.28,101.04) v2(6.05,104.09) v2(6.05,103.33) v2(6.05,102.57) v2(6.05,101.8) v2(6.05,101.04) v2(6.17,163.4) v2(6.17,162.51) v2(6.17,159.59) v2(6.17,158.7) v2(7.06,163.4) v2(7.06,162.51) v2(7.06,159.59) v2(7.06,158.7)
POE_INT#: length 162.7
  TOP w0.107: U13.17 v1(141.33,76.96) ; U65.45 16.76,79.91 16.05,80.62 RB45.1 15.6,80.62 v1(15.14,81.08)
  IN3 w0.124: v1(15.14,81.08) 15.94,81.08 15.94,81.07 17.55,81.07 18.21,80.41 20.88,80.41 25.98,75.31 34.6,75.31 35.45,74.46 35.45,70.95 40.74,65.66 40.74,61.47 46.61,55.59 67.37,55.59 72.04,50.92 76.78,50.92 77.85,51.99 78.56,51.99 87.91,51.99 90.5,54.58 93.54,54.58 96.7,57.75 105.59,57.75 106.21,57.12 111.06,57.12 117.74,63.8 122.61,63.8 123.36,64.55 123.36,71.74 125.81,74.19 129.82,74.19 131.5,75.87 140.23,75.87 v1(141.33,76.96)
POE_OUT1A: length 43.7
  TOP w1.016: FB8.2 11.38,15.09 1.78,24.69 1.78,53.77 2.06,54.05
  vias: v1(2.24,54.94) v1(2.24,54.31)
POE_OUT1B: length 56
  TOP w1.016: v1(10.29,40.49) 4.01,34.21 4.01,25.1 11.38,17.73 21.29,17.73 23.19,15.82 FB11.2
  IN2 w1.016: 9.73,53.34 9.73,45.64 11.3,44.07 11.3,40.61 v1(11.18,40.49)
  vias: v1(9.73,55.07) v1(9.73,54.43)
POE_OUT2: length 71.7
  IN2 w1.016: 3.61,68.25 3.76,68.1 3.66,68 3.66,53.31 3.12,52.78 3.12,40.26 6.3,37.08 11.61,37.08 16.81,31.88 16.81,27.53 20.68,23.67 26.42,23.67 28.6,21.49 28.6,19.71 32.03,16.28 32.03,15.37
  vias: v1(3.12,69.16) v1(3.76,69.16) v1(33.15,15.37) v1(33.78,15.37)
POE_OUT3: length 87.1
  IN2 w1.016: 53.11,15.11 52.11,16.12 52.11,25.95 50.55,27.51 50.55,32.51 48.82,34.24 40.39,34.24 40.03,33.88 31.7,33.88 28.5,37.08 16.13,37.08 14.48,38.73 14.48,43.21 11.33,46.35 11.33,65.91 10.46,66.78
  vias: v1(9.73,68.15) v1(9.73,67.51) v1(53.34,15.37) v1(53.98,15.37)
POE_OUT4: length 85.3
  IN2 w1.016: 17.27,53.44 17.22,53.39 17.22,43.05 18.52,41.76 37.52,41.76 40.87,38.4 43.76,38.4 44.86,37.31 49.12,37.31 50.11,36.32 57.43,36.32 59.59,34.16 67.36,34.16 68.63,32.89 68.63,27.41 70.48,25.55 70.48,17.3 72.54,15.24
  vias: v1(17.22,54.94) v1(17.22,54.31) v1(73.53,15.37) v1(74.17,15.37)
POE_OUT5: length 95.4
  IN2 w1.016: 24.89,53.62 26.42,52.1 26.42,45.11 27.99,43.54 38.35,43.54 41.12,40.77 52.04,40.77 54.33,38.48 61.37,38.48 63.14,36.7 68.12,36.7 68.38,36.45 84.07,36.45 86.69,33.83 86.69,28.35 88.82,26.21 88.82,18.54 92,15.37 92.61,15.37
  vias: v1(24.59,54.94) v1(24.59,54.31) v1(93.73,15.37) v1(94.36,15.37)
POE_OUT6: length 127.7
  IN2 w1.016: 17.55,66.95 17.55,63.2 20.29,60.45 25.65,60.45 32,54.1 32,48.39 35,45.39 38.96,45.39 41.78,42.57 56.01,42.57 58.06,40.51 67.26,40.51 69.09,38.68 80.24,38.68 80.85,38.07 84.79,38.07 86.51,36.35 93.73,36.35 95.78,34.29 103.15,34.29 104.44,32.99 104.44,30.38 105.82,29.01 105.82,27.08 108.28,24.61 108.28,20.27 112.01,16.54 112.01,15.6 112.45,15.16
  vias: v1(17.22,68.15) v1(17.22,67.51) v1(113.92,15.37) v1(114.55,15.37)
POE_OUT7: length 143.5
  IN2 w1.016: 133.3,15.37 132.89,15.37 128.23,20.03 120.84,20.03 118.77,22.1 118.77,30.99 117.37,32.38 114.33,32.38 113.18,33.53 113.18,34.47 111.33,36.32 100.74,36.32 98.4,38.66 88.37,38.66 85.37,41.66 78.05,41.66 77.19,40.79 69.24,40.79 68.05,41.99 58.85,41.99 56.69,44.15 44.86,44.15 41.63,47.37 35.99,47.37 34.19,49.17 34.19,62.33 30.53,65.99 26.14,65.99 25.3,66.83
  vias: v1(24.71,68.15) v1(24.71,67.51) v1(134.19,15.34) v1(134.82,15.34)
POE_RST#: length 2.9
  TOP w0.107: U65.44 17.26,79.47 18.16,80.37 CA248.1 17.11,80.63 RB46.1
POE_SCL: length 161.9
  TOP w0.107: RB44.1 13.48,80.67 12.85,80.04 v1(12.85,79.88) 12.85,79.81 12.76,79.72 U65.53 ; U13.12 v1(144.55,71.8)
  IN3 w0.124: v1(12.85,79.88) 12.85,79.43 13.03,79.25 17.63,79.25 17.93,79.55 20.53,79.55 25.63,74.45 34.14,74.45 34.59,73.99 34.59,70.46 39.74,65.31 39.74,61.25 46.26,54.73 67.02,54.73 71.69,50.06 77.14,50.06 78.21,51.13 88.26,51.13 90.85,53.72 93.89,53.72 96.41,56.24 111.68,56.24 117.75,62.31 122.63,62.31 125.35,65.02 130.73,65.02 132.23,66.52 138.66,66.52 141.32,69.18 143.07,69.18 143.66,69.77 143.66,70.91 v1(144.55,71.8)
POE_SDA: length 160
  TOP w0.107: RZ64.2 v1(11.96,81.64) RZ63.2 ; U13.11 v1(142.27,71.3)
  IN3 w0.124: v1(11.96,81.64) 12.95,80.64 17.37,80.64 18.03,79.98 20.71,79.98 25.81,74.88 34.39,74.88 35.02,74.25 35.02,70.64 40.17,65.49 40.17,61.43 46.44,55.16 67.19,55.16 71.87,50.49 76.96,50.49 78.03,51.56 78.38,51.56 88.08,51.56 90.68,54.15 93.72,54.15 96.87,57.3 105.41,57.3 106.02,56.69 111.53,56.69 117.58,62.74 122.45,62.74 125.25,65.53 128,65.53 130,67.53 136.49,67.53 140.26,71.3 v1(142.27,71.3)
  BOTTOM w0.107: RB65.1 11.99,81.61 v1(11.96,81.64)
POE_SHUTDOWN: length 156.2
  TOP w0.107: RZU30.2 v1(122.81,78.49) ; v1(10.16,82.27) RZ62.2
  IN3 w0.124: v1(10.16,82.27) 10.16,82.32 10.45,82.61 20.16,82.61 23.99,78.78 35,78.78 35.7,78.08 35.7,71.06 40.99,65.76 40.99,61.62 46.76,55.84 67.48,55.84 72.15,51.17 76.68,51.17 77.75,52.24 78.67,52.24 78.67,52.24 87.8,52.24 90.39,54.83 93.43,54.83 98.46,59.86 104.82,59.86 107.3,57.37 110.95,57.37 117.63,64.05 122.5,64.05 123.1,64.66 123.1,71.85 123.8,72.54 123.8,77.5 v1(122.81,78.49)
POE_VCC: length 1.4
  TOP w0.229: U65.17 v1(12.26,70.56) v1(12.9,70.56)
  vias: v1(7.95,64.21) v1(7.95,63.45) v1(7.95,62.69) v1(7.95,51) v1(7.95,50.24) v1(7.95,49.48) v1(13.79,15.32) v1(14.43,15.32) v1(15.44,64.21) v1(15.44,63.45) v1(15.44,62.69) v1(15.44,51) v1(15.44,50.24) v1(15.44,49.48) v1(18.62,15.32) v1(19.25,15.32) v1(22.94,64.21) v1(22.94,63.45) v1(22.94,62.69) v1(22.94,51) v1(22.94,50.24) v1(22.94,49.48) v1(30.3,51) v1(30.3,50.24) v1(30.3,49.48) v1(30.43,64.21) v1(30.43,63.45) v1(30.43,62.69) v1(37.34,15.37) v1(38.1,15.37) v1(57.53,15.37) v1(58.29,15.37) v1(77.72,15.37) v1(78.49,15.37) v1(97.92,15.37) v1(98.68,15.37) v1(118.11,15.37) v1(118.87,15.37) v1(138.35,15.34) v1(138.96,15.34) v2(18.36,88.47) v2(18.36,87.71) v2(18.36,86.94) v2(18.36,86.18) v2(18.36,85.42) v2(18.36,84.66) v2(19.13,88.47) v2(19.13,87.71) v2(19.13,86.94) v2(19.13,86.18) v2(19.13,85.42) v2(19.13,84.66)
POWER_BTN_DEB_N: length 47
  TOP w0.107: RB7.2 v1(131.06,159.77) 131.03,159.73 U6.8 ; v1(106.5,135.89) J1.L61
  IN1 w0.124: v1(131.06,159.77) 127.1,159.77 125.24,157.91 125.24,156.48 122.55,153.79 118.51,153.79 113.18,148.46 113.18,137.29 111.15,135.25 107.14,135.25 v1(106.5,135.89)
PREXT1: length 4
  BOTTOM w0.107: R558.1 68.1,108.2 69.55,106.76 69.55,105.83 U67.AB2
PREXT2: length 1.3
  TOP w0.305: v3(55.96,93.82) 55.98,93.8 R559.1
  BOTTOM w0.107: U67.E16 56.36,94.22 v3(55.96,93.82)
PSE_D1: length 27
  TOP w0.229: v1(9.83,77.65) 9.98,77.5 U65.3
  IN1 w0.508: v1(6.87,54.88) 6.69,54.88 5.99,55.58 5.99,57.51 5.44,58.06 5.44,74.65 8.13,77.34 9.52,77.34 v1(9.83,77.65)
PSE_D2: length 25.3
  TOP w0.229: U65.5 v1(9.86,76.5)
  IN1 w0.508: v1(9.86,76.5) 9.53,76.5 9.02,75.99 9.02,75.18 8.61,74.78 8.61,66.07 9.6,65.07 9.6,61.29 14.3,56.59 v1(14.3,55.07)
PSE_D3: length 11.5
  TOP w0.229: 9.02,74 U65.10
  TOP w0.508: F3.1 5.21,68.53 5.21,73.49 5.71,74 9.02,74
PSE_D4: length 10.3
  TOP w0.254: U65.12 9.6,73 9.19,72.59
  TOP w0.508: 9.19,72.59 8.76,72.16 8.76,70.21 9.3,69.67 12.65,69.67 13.34,68.99 F4.1
PSE_D5: length 21.3
  TOP w0.203: v1(19.15,72.82) 18.97,73 U65.31
  IN1 w0.508: v1(19.15,72.82) 20.02,72.82 20.95,71.88 20.95,70.48 19.58,69.11 19.58,57.86 20.74,56.71 20.74,56.17 v1(21.79,55.12)
PSE_D6: length 29
  TOP w0.254: v1(20.57,73.76) 20.33,74 U65.33
  IN1 w0.508: v1(20.57,73.76) 20.57,73.71 21.89,72.39 21.89,70.03 20.7,68.83 20.7,58.12 21.56,57.25 22.43,57.25 23.62,56.06 23.62,53.8 24.13,53.29 v1(27.41,53.29)
PSE_D7: length 11.1
  TOP w0.229: U65.38 19.54,76.5 19.74,76.3
  TOP w0.508: 19.74,76.3 20.88,75.16 21.54,75.16 22.68,74.02 22.68,69.19 22.02,68.53 21.97,68.53
PSE_D8: length 20.1
  TOP w0.229: 19.68,77.72 19.46,77.5 U65.40
  TOP w0.508: 19.68,77.72 20.14,78.18 23.32,78.18 24.1,77.39 24.1,71.4 25.1,70.41 27.64,70.41 28.32,69.72 F8.1 28.32,66.83
PSE_GATE1: length 43.1
  TOP w0.203: U65.1 10.37,78.5 10.19,78.69 v1(9.86,78.69)
  TOP w0.508: v1(6.78,45.52) 6.99,45.72 Q20.4
  IN1 w0.508: v1(6.78,45.52) 6.86,45.59 6.86,52.6 2.24,57.23 2.24,75.18 6.35,79.3 9.25,79.3 v1(9.86,78.69)
PSE_GATE2: length 35.3
  TOP w0.229: U65.7 v1(9.91,75.5)
  TOP w0.508: v1(14.35,45.42) Q21.4
  IN1 w0.508: v1(14.35,45.42) 14.35,52.96 16.21,54.81 16.21,64.47 10.87,69.8 10.87,74.51 10.51,74.87 v1(9.91,75.5)
PSE_GATE3: length 20.7
  TOP w0.229: U65.8 v1(7.37,75)
  TOP w0.508: Q22.4 v1(6.86,58.72)
  IN1 w0.508: v1(7.37,75) 6.86,74.49 v1(6.86,58.72)
PSE_GATE4: length 16.8
  TOP w0.229: U65.14 10.41,72 9.91,71.5 v1(9.83,71.5)
  TOP w0.508: v1(14.35,58.62) Q23.4
  IN1 w0.508: v1(9.83,71.5) 9.83,69.19 14.35,64.67 v1(14.35,58.62)
PSE_GATE5: length 30.3
  TOP w0.203: U65.29 18.6,72 18.87,71.73 v1(18.87,71.5)
  TOP w0.508: v1(21.84,45.52) Q24.4
  IN1 w0.508: v1(21.84,45.52) 21.84,51.84 17.35,56.34 17.35,63.7 18.57,64.92 18.57,70.99 18.87,71.3 v1(18.87,71.5)
PSE_GATE6: length 38.3
  TOP w0.229: v1(19.76,74.5) 19.76,74.63 19.39,75 U65.35
  TOP w0.508: v1(29.21,45.52) Q25.4
  IN1 w0.508: v1(19.76,74.5) 19.76,74.96 20.27,75.46 21.72,75.46 23.85,73.33 23.85,65.96 27.61,62.2 27.61,58.04 29.21,56.44 v1(29.21,45.52)
PSE_GATE7: length 21
  TOP w0.229: v1(20.65,74.5) 20.65,74.54 19.78,75.41 18.82,75.41 18.73,75.5 U65.36
  TOP w0.508: v1(21.84,58.72) Q26.4
  IN1 w0.508: v1(20.65,74.5) 21.08,74.5 22.83,72.75 22.83,69.27 21.84,68.28 v1(21.84,58.72)
PSE_GATE8: length 27.9
  TOP w0.229: v1(19.25,78.94) 19.13,78.94 18.68,78.5 U65.42
  TOP w0.508: v1(29.34,58.62) Q27.4
  IN1 w0.508: v1(29.34,58.62) 29.34,65.13 24.99,69.47 24.99,73.66 23.34,75.31 23.34,76.99 21.39,78.94 v1(19.25,78.94)
PSE_SEN1: length 46.6
  TOP w0.203: U65.2 10.26,78 10.09,78.18 v1(9.35,78.18)
  TOP w0.508: R496.2 v1(4.83,42.95)
  IN3 w0.381: v1(9.35,78.18) 6.93,78.18 4.52,75.77 4.52,68.33 2.49,66.29 2.49,55.91 5.03,53.37 5.03,49.54 8.08,46.49 8.08,44.75 6.27,42.95 v1(4.83,42.95)
PSE_SEN2: length 44.3
  TOP w0.229: U65.6 v1(7.98,76)
  TOP w0.508: R497.2 v1(12.57,42.93)
  IN3 w0.381: v1(12.57,42.93) 11.13,42.93 9.09,44.96 9.09,46.91 6.05,49.96 6.05,53.79 3.51,56.33 3.51,65.87 5.54,67.9 5.54,75.11 6.43,76 v1(7.98,76)
PSE_SEN3: length 24.9
  TOP w0.254: v1(9.55,74.5) U65.9
  TOP w0.381: R498.2 v1(4.83,56.18)
  IN3 w0.381: v1(4.83,56.18) 4.83,56.24 6.05,57.45 7.67,57.45 8.71,58.5 8.71,65.72 7.07,67.36 7.07,71.77 9.55,74.25 v1(9.55,74.5)
PSE_SEN4: length 21.1
  TOP w0.229: v1(9.83,72.21) 9.83,72.27 10.06,72.5 U65.13
  TOP w0.381: R499.2 v1(12.57,56.18)
  IN3 w0.381: v1(12.57,56.18) 11.33,56.18 9.73,57.78 9.73,66.14 8.64,67.23 8.64,71.12 9.73,72.21 v1(9.83,72.21)
PSE_SEN5: length 38.5
  TOP w0.229: v1(19.1,72.2) 18.8,72.5 U65.30
  TOP w0.381: 19.68,44.2 v1(19.68,42.93)
  IN3 w0.381: v1(19.1,72.2) 19.48,71.81 19.48,68.35 16.56,65.43 16.56,59.36 15.34,58.14 15.34,53.54 23.09,45.8 23.09,45.14 20.88,42.93 v1(19.68,42.93)
PSE_SEN6: length 42.1
  TOP w0.229: U65.34 v1(19.12,74.5)
  TOP w0.508: R501.2 28.19,44.2 28.7,44.7 v1(28.7,44.81)
  IN3 w0.381: v1(28.7,44.81) 24.59,44.81 24.13,45.26 24.13,46.19 16.36,53.96 16.36,57.72 17.58,58.94 17.58,65.01 20.83,68.26 20.83,72.14 19.12,73.84 v1(19.12,74.5)
PSE_SEN7: length 27.1
  TOP w0.229: U65.37 19.02,76 v1(19.1,75.92)
  TOP w0.381: R502.2 v1(19.81,56.18)
  IN3 w0.381: v1(19.81,56.18) 21.05,57.42 22.25,57.42 22.96,58.14 22.96,61.01 23.83,61.87 23.83,65.18 22.05,66.95 22.05,74.39 20.21,76.23 19.41,76.23 v1(19.1,75.92)
PSE_SEN8: length 30
  TOP w0.229: v1(19.25,78.18) 19.07,78 U65.41
  TOP w0.508: 27.56,57.4 v1(27.56,56.18)
  IN3 w0.381: v1(19.25,78.18) 19.25,77.98 19.74,77.5 21.44,77.5 23.06,75.87 23.06,67.38 24.84,65.6 24.84,61.45 23.98,60.59 23.98,58.5 25.07,57.4 26.34,57.4 v1(27.56,56.18)
PSELF: length 4.9
  TOP w0.203: U20.6 87.41,64.95 87.96,64.4 90.21,64.4 R165.1
  TOP w0.254: RA8.1 90.61,64.43 R165.1
PWM01_BKLIGHT_GMSL_INT3_GP68: length 7.4
  TOP w0.107: J1.K57 103.1,132.3 103.35,132.55 103.35,133.38 102.87,133.86 RZ18.2
PWREN1#: length 2.3
  TOP w0.203: R155.2 87.99,70.43 87.3,69.75 U20.18
PWREN2#: length 2.8
  TOP w0.203: U20.4 87.3,64.15 88.01,63.43 88.01,62.64 88.22,62.43 R156.2
PWREN3#: length 1.9
  TOP w0.107: U20.53 76.63,64.55 76.54,64.47 R157.2
PWREN4#: length 2
  TOP w0.107: R158.2 77.67,72.15 78.5,71.32 78.71,71.32 78.82,71.21 U20.38
RI2#: length 2.6
  TOP w0.254: U25.31 77.54,154.25 76.33,153.03 TP35.1
RTERM: length 1.9
  TOP w0.107: U20.51 77.42,65.35 77.25,65.18 R167.1
RTS2#: length 3.9
  TOP w0.107: U25.30 77.5,154.65 76.4,153.54 75.82,153.54 TP36.1
RX_PAVDD_A: length 2.4
  TOP w0.203: U66.52 v1(97.09,90.63) ; v1(98.58,90.55) 98.29,90.27 U66.49 ; U66.57 v1(95.09,90.63)
RXNE_UP: length 2
  TOP w0.102: U20.36 79.62,71.3 79.55,71.37 79.55,71.61 79.15,72.01 78.9,72.01 78.79,72.12 78.79,72.17 CA23.2
RXPE_UP: length 2
  TOP w0.102: U20.37 79.22,71.3 79.3,71.37 79.3,71.5 79.04,71.75 78.8,71.75 78.54,72.02 78.54,72.2 CA24.2
SAFE_3V3: length 5.7
  TOP w0.107: RZ15.2 99.44,136.28 99.3,136.14 J1.L53
SBU1: length 7.2
  BOTTOM w0.102: RZ207.2 65.91,51.36 65.91,51.13 65.75,50.97 65.75,50.74 65.62,50.61 D66.1 D66.10 65.62,49.16 65.75,49.04 65.75,47.21 65.53,46.98 65.53,45.97 65.42,45.87 USB1.6
SBU2: length 7.2
  BOTTOM w0.102: USB1.8 65.88,45.87 65.78,45.97 65.78,46.88 66,47.1 66,49.03 66.12,49.16 D66.9 D66.2 66.12,50.61 66,50.74 66,50.86 66.17,51.03 66.17,51.33 RZ208.2
SDMMC1_CLK: length 114.1
  TOP w0.107: RZU18.1 130.18,126.77 130.18,127.24 125.35,132.07 125.35,136.74 124.05,138.04 115.45,138.04 111.66,141.83 95.12,141.83 arc(94.89,141.74) 94.79,141.51 94.79,140.34 arc(94.71,140.12) 94.5,140.04 94.35,140.04 arc(94.14,140.12) 94.05,140.34 94.05,141.51 arc(93.96,141.74) 93.73,141.83 93.6,141.83 arc(93.4,141.75) 93.31,141.55 93.31,140.27 arc(93.24,140.1) 93.07,140.04 92.84,140.04 arc(92.65,140.11) 92.57,140.3 92.57,141.57 arc(92.49,141.76) 92.3,141.83 92.08,141.83 arc(91.9,141.76) 91.83,141.59 91.83,140.3 arc(91.75,140.11) 91.57,140.04 67.45,140.04 65.59,138.17 54.86,138.17 v1(54.62,137.92) ; J1.B6 v1(54.4,120.02)
  IN3 w0.124: v1(54.62,137.92) 54.62,137.01 53.98,136.37 53.98,133.26 54.23,133.01 54.23,131.6 53.78,131.15 53.78,120.75 54.4,120.13 v1(54.4,120.02)
SDMMC1_CMD: length 112.9
  TOP w0.107: RZU13.1 125.74,132.23 125.74,136.9 124.21,138.43 115.61,138.43 111.82,142.22 91.44,142.22 arc(91.26,142.14) 91.18,141.96 91.18,140.69 arc(91.11,140.51) 90.93,140.44 90.72,140.44 arc(90.52,140.52) 90.44,140.72 90.44,141.95 arc(90.36,142.14) 90.17,142.22 89.94,142.22 arc(89.77,142.15) 89.7,141.99 89.7,140.71 arc(89.62,140.51) 89.41,140.42 67.29,140.42 65.43,138.55 54.75,138.55 v1(54.62,138.68) ; J1.A5 v1(53.3,118.52)
  IN3 w0.124: v1(53.3,118.52) 53.35,118.57 53.35,131.64 53.08,131.91 53.08,132.66 53.31,132.89 53.31,136.31 54.13,137.13 54.13,138.56 54.25,138.68 v1(54.62,138.68)
SDMMC1_D0: length 114.6
  TOP w0.107: RZU14.1 133.1,126.87 132.59,127.38 131.27,127.38 126.12,132.53 126.12,137.06 124.37,138.82 115.77,138.82 111.98,142.61 89.53,142.61 arc(89.3,142.51) 89.2,142.28 89.2,141.1 arc(89.12,140.9) 88.93,140.82 88.77,140.82 arc(88.55,140.91) 88.46,141.13 88.46,142.28 arc(88.37,142.51) 88.14,142.61 88.01,142.61 arc(87.81,142.52) 87.72,142.32 87.72,141.04 arc(87.66,140.88) 87.5,140.82 87.25,140.82 arc(87.06,140.9) 86.98,141.09 86.98,142.37 arc(86.91,142.54) 86.74,142.61 86.49,142.61 arc(86.31,142.53) 86.24,142.36 86.24,141.08 arc(86.16,140.89) 85.98,140.82 85.72,140.82 arc(85.56,140.88) 85.5,141.05 85.5,142.33 arc(85.41,142.52) 85.22,142.61 84.99,142.61 arc(84.82,142.54) 84.75,142.37 84.75,141.1 arc(84.67,140.9) 84.48,140.82 67.14,140.82 65.27,138.94 56.31,138.94 56.06,139.19 v1(56.03,139.19) ; J1.E8 v1(56,124.49)
  IN3 w0.124: v1(56,124.49) 55.58,124.91 55.58,126.29 55.28,126.58 55.28,128.08 54.68,128.68 54.68,130.84 55.09,131.24 55.09,132.36 56.03,133.31 v1(56.03,139.19)
SDMMC1_D1: length 115.3
  TOP w0.107: J1.F8 56.2,125.84 v1(56.02,126.02) ; RZU15.1 134.9,127.38 134.11,127.38 126.51,134.99 126.51,137.22 124.53,139.2 115.93,139.2 112.14,142.99 84.58,142.99 arc(84.35,142.9) 84.25,142.66 84.25,141.48 arc(84.18,141.3) 84,141.22 83.77,141.22 arc(83.59,141.3) 83.51,141.48 83.51,142.75 arc(83.44,142.92) 83.27,142.99 83.06,142.99 arc(82.85,142.91) 82.77,142.7 82.77,141.48 arc(82.7,141.3) 82.52,141.22 82.28,141.22 arc(82.1,141.3) 82.03,141.48 82.03,142.75 arc(81.96,142.92) 81.79,142.99 81.53,142.99 arc(81.36,142.92) 81.29,142.75 81.29,141.48 arc(81.21,141.3) 81.03,141.22 80.8,141.22 arc(80.62,141.3) 80.55,141.48 80.55,142.51 arc(80.46,142.71) 80.26,142.79 80.1,142.79 arc(79.89,142.7) 79.8,142.49 79.8,141.4 arc(79.75,141.28) 79.63,141.22 79.32,141.22 arc(79.14,141.3) 79.06,141.48 79.06,142.49 arc(78.98,142.7) 78.77,142.79 78.61,142.79 arc(78.41,142.7) 78.32,142.5 78.32,141.44 arc(78.26,141.29) 78.11,141.22 67,141.22 65.23,139.45 v1(56.76,139.45)
  IN3 w0.124: v1(56.02,126.02) 56.02,126.45 55.71,126.76 55.71,128.26 55.52,128.45 55.52,132.19 56.76,133.43 v1(56.76,139.45)
SDMMC1_D2: length 115.8
  TOP w0.107: RZU10.1 137.38,127.77 134.27,127.77 126.89,135.15 126.89,137.38 124.69,139.59 116.09,139.59 112.3,143.38 78.33,143.38 76.57,141.61 66.84,141.61 65.19,139.95 56.21,139.95 56.01,139.75 54.66,139.75 v1(54.48,139.57) ; J1.A4 v1(52.4,118.52)
  IN3 w0.124: v1(52.4,118.52) 52.18,118.74 52.18,129.52 52.92,130.26 52.92,131.05 52.18,131.8 52.18,136.14 53.19,137.14 53.19,138.28 v1(54.48,139.57)
SDMMC1_D3: length 114.8
  TOP w0.107: v1(55.7,140.28) 55.76,140.34 65.03,140.34 66.7,142.01 74.69,142.01 arc(74.95,142.12) 75.05,142.37 75.05,143.5 arc(75.13,143.69) 75.31,143.76 75.53,143.76 arc(75.71,143.69) 75.79,143.5 75.79,142.29 arc(75.87,142.09) 76.07,142.01 76.23,142.01 arc(76.44,142.1) 76.53,142.31 76.53,143.46 arc(76.62,143.68) 76.83,143.76 112.46,143.76 116.25,139.97 124.85,139.97 127.28,137.54 127.28,135.31 134.43,128.15 138.14,128.15 RZU11.1 ; J1.D6 v1(54.4,123.02)
  IN3 w0.124: v1(55.7,140.28) 55.58,140.16 55.58,136.75 54.9,136.08 54.9,132.78 54.66,132.54 54.66,131.42 54.25,131.01 54.25,123.16 v1(54.4,123.02)
SNN_EFM8_P1_7: length 1.9
  TOP w0.107: TP59.1 131.53,159.73 U6.7
SNN_EFM8SB10_P0_1: length 1.8
  TOP w0.107: U6.1 132.05,155.83 132.46,155.41 TP57.1
SNN_EFM8SB10_P0_2: length 2.7
  TOP w0.107: U6.20 131.53,155.49 131.7,155.32 TP58.1
SNN_EFM8SB10_P0_5: length 1.7
  TOP w0.107: TP56.1 129.67,155.21 130.03,155.57 U6.17
SNN_GP92_CAN2: length 1.4
  TOP w0.107: J1.F40 v1(87.8,126.02)
  BOTTOM w0.107: TP3.1 87.81,126.03 v1(87.8,126.02)
SNN_GP93_CAN2: length 1.5
  TOP w0.107: J1.D40 v1(87.8,123.02)
  BOTTOM w0.107: v1(87.8,123.02) 87.8,122.32 TP4.1
SNN_GP94_CAN2: length 1.5
  TOP w0.107: J1.B40 v1(87.8,120.02)
  BOTTOM w0.107: TP5.1 87.93,119.89 v1(87.8,120.02)
SNN_MID1: length 1.4
  TOP w0.107: J1.H40 v1(87.8,129.02)
  BOTTOM w0.107: TP2.1 87.83,128.99 v1(87.8,129.02)
SOC_PWR_REQ: length 16.8
  TOP w0.107: RZU8.1 119.28,134.24 U33.2 115.57,134.24 115.44,134.11 115.44,133.1 115.06,132.72 110.11,132.72 v1(109.47,132.08) ; J1.J60 v1(105.6,130.52)
  IN1 w0.124: v1(109.47,132.08) 108.99,131.59 106.97,131.59 106.49,131.11 106.35,131.11 105.75,130.52 v1(105.6,130.52)
SPI1_CS0: length 22.7
  TOP w0.107: RZ43.1 v1(101.73,104.9) ; J1.E55 v1(101.1,124.52)
  IN3 w0.124: v1(101.73,104.9) 102.87,106.04 102.87,117.53 103.52,118.18 103.52,121.02 103.35,121.18 103.35,121.95 102.29,123.01 102.29,123.33 v1(101.1,124.52)
SPI1_MISO: length 10.2
  TOP w0.107: RZ29.1 v1(101.73,109.7) ; J1.A56 v1(102,118.52)
  IN3 w0.124: v1(102,118.52) 101.86,118.38 101.86,109.83 v1(101.73,109.7)
SPI1_MOSI: length 17.8
  TOP w0.107: J1.D55 v1(101.3,123.02) ; RZ34.1 v1(101.73,107.31)
  IN3 w0.124: v1(101.3,123.02) 101.3,121.6 102.49,120.41 102.49,118.11 102.36,117.98 102.36,107.95 v1(101.73,107.31)
SPI1_SCK: length 28.5
  TOP w0.107: v1(102.92,104.9) 102.87,104.85 RZ44.1 ; J1.J57 v1(102.9,130.56)
  IN3 w0.124: v1(102.9,130.56) 103.54,129.91 103.54,128.56 103.38,128.4 103.38,126.62 103.53,126.47 103.53,125.5 103.38,125.35 103.38,123.85 103.56,123.67 103.56,122.53 104.27,121.82 104.27,121.11 104.42,120.96 104.42,118.36 103.37,117.32 103.37,105.35 v1(102.92,104.9)
SPKOUT: length 5.9
  BOTTOM w0.508: R139.1 2.41,193.54 BUZZ1.1
SRC_ON_D: length 3.8
  TOP w0.508: Q34.D 68.71,155.07 66.56,155.07 66.56,155.65 66.6,155.69 R667.2
STANDBY_REQ_N_GP109: length 13.7
  TOP w0.107: RZU6.2 50.04,139.57 51.16,138.46 51.16,137.16 51.69,136.63 56.39,136.63 58.7,134.31 J1.L11
SW2CLK: length 21.1
  TOP w0.107: U13.52 135.33,63.16 v1(135.15,62.99)
  BOTTOM w0.107: v1(135.15,62.99) 134.68,63.47 132.58,63.47 132.11,62.99 121.64,62.99 121.31,62.66 118.31,62.66 117.63,61.98 DB1.4
SW2DIO: length 22.2
  TOP w0.107: v1(136.04,62.99) 135.83,63.21 U13.53
  BOTTOM w0.107: DB1.2 117.37,64.52 118.01,63.88 121.31,63.88 121.79,63.4 131.93,63.4 132.41,63.88 135.15,63.88 v1(136.04,62.99)
SW2O: length 18.2
  TOP w0.107: U13.50 v1(134.33,65.66)
  BOTTOM w0.107: v1(134.33,65.66) 133.76,65.66 131.73,63.64 122.32,63.64 121.56,64.39 121.56,65.53 121.31,65.79 DB1.6
SYS_RST_IN_N: length 119.6
  TOP w0.107: v1(124.84,152.65) 125.35,153.16 125.35,156.61 125.24,156.72 Q2.5 ; R144.2 123.34,122.2 v1(122.17,121.03) 121.62,120.47 TP30.1 ; J1.L60 105.6,133.29 v1(105.79,133.48)
  IN1 w0.124: v1(105.79,133.48) 105.94,133.48 106.37,133.91 118.9,133.91 119.91,132.89 v1(123.7,132.89) ; v1(150.77,91.19) 151.03,91.19 151.66,91.82 151.66,98.12 148.6,101.18 148.6,105.8 148.03,106.38 138.81,106.38 138.25,106.93 135.81,106.93 132.97,109.78 v1(122.17,109.78)
  IN3 w0.124: v1(124.84,152.65) 124.84,152.37 125.64,151.57 125.64,141.61 125.16,141.12 125.16,134.35 v1(123.7,132.89) 123.38,132.57 123.38,122.24 v1(122.17,121.03) v1(122.17,109.78)
  BOTTOM w0.107: J4.10 122.56,121.41 v1(122.17,121.03) ; RZ188.1 v1(150.77,91.19) ; RZ150.2 v1(124.84,152.65)
SYS_RST_IN_N_CON: length 46.8
  IN1 w0.124: v1(149.71,137.9) 149.2,137.9 147.82,136.51 136.47,136.51 134.43,138.56 130.58,138.56 125.98,143.15 v1(125.98,152.65)
  BOTTOM w0.107: v1(149.71,137.9) 149.72,137.91 149.72,138.8 150.9,139.98 R681.2 153.15,139.98 CA133.1 154.01,139.99 155.84,138.17 RESET1.3 ; RZ149.1 v1(125.98,152.65)
SYS_RST_IN_N_KEY: length 10.9
  BOTTOM w0.107: C134.1 123.71,154.28 RZ150.1 RZ149.2 ; C134.1 122.57,154.27 Z9.2 ; C134.1 123.7,155.83 123.89,156.02 PSON2.2 PSON2.1
SYS_RST_IN_Q: length 5.3
  TOP w0.107: Q2.3 122.06,156.07 121.92,156.21 121.92,156.59 122.05,156.72 ; 122.05,156.72 121.92,156.84 121.92,158.75 122.3,159.13 RB8.2 ; 122.05,156.72 Q2.2
SYSRST#_OOB: length 2.1
  BOTTOM w0.107: RZ188.2 152.64,91.2 OOB1.8
SYSTEM_OC_N: length 27.7
  TOP w0.107: RZ20.2 121.79,129.21 120.85,128.27 118.49,128.27 113.97,123.75 113.97,118.64 112.7,117.38 106.98,117.38 J1.A61
SYSTEM_OC_N_BU: length 3.6
  TOP w0.107: R240.1 120.52,135.66 Z18.2 RZ20.1 RZU9.2
TCA6408A_ADDR: length 3.1
  TOP w0.203: R90.2 R91.1 127.27,74.66 U14.16
TPM_CS#: length 3.8
  TOP w0.107: U18.20 v1(110.32,89.03)
  BOTTOM w0.107: v1(110.32,89.03) 110.63,89.33 Q51.6 110.59,90.65 R771.1
TPM_IRQ#: length 40.8
  TOP w0.107: U18.18 v1(111.32,89.03) 111.32,89.4 111.38,89.46 RB42.2 ; v1(118.38,120.55) 118.66,120.27 Q57.D
  IN3 w0.124: v1(118.38,120.55) 119,119.93 119,112.88 117.48,111.36 117.48,107.31 112.67,102.49 112.67,97.63 114.14,96.16 114.14,91.13 112.04,89.03 v1(111.32,89.03)
  BOTTOM w0.107: R1474.1 v1(118.38,120.55)
TPM_PP: length 2.9
  TOP w0.254: R1488.2 R768.2 111.32,81.94 U18.7
TPM_SPI_CS0: length 18.3
  TOP w0.107: v1(107.77,96.47) 107.77,97.1 101.73,103.15 RZ43.2
  BOTTOM w0.107: v1(107.77,96.47) 107.32,96.02 107.32,92.65 108.79,91.19 111.02,91.19 111.28,90.93 Q51.5
TPM_SPI_MISO: length 20.8
  TOP w0.107: RZ29.2 102.36,108.1 102.77,107.7 102.77,106.51 104.42,104.86 104.42,102.92 106.2,101.14 109.57,101.14 arc(109.94,100.77) 109.57,100.4 107.91,100.4 arc(107.54,100.03) 107.91,99.66 109.27,99.66 arc(109.56,99.54) 109.67,99.26 U86.6
TPM_SPI_MOSI: length 12.4
  TOP w0.107: U86.8 108.87,97.78 103.91,102.74 103.91,104.67 102.92,105.66 101.75,105.66 RZ34.2
TPM_SPI_SCK: length 9.5
  TOP w0.107: RZ44.2 102.87,102.77 108.36,97.28 108.36,96.46 108.46,96.36 U86.9
TX0N_A: length 32.7
  TOP w0.089: CB23.1 94.16,76.14 94.16,74.91 v1(93.94,74.7)
  BOTTOM w0.089: L10.4 102.25,53.79 101.99,54.05 101.99,54.32 102.18,54.51 102.18,54.71 R507.1 102.18,55.58 102.18,57.02 101.99,57.21 101.99,65.14 102.73,65.87 102.73,72.89 99.88,75.74 94.59,75.74 94.16,75.31 94.16,74.91 v1(93.94,74.7)
TX0N_A-E: length 5.4
  BOTTOM w0.089: L10.3 102.25,51.58 102.01,51.33 102.01,50.52 102.12,50.41 D56.2 D56.9 102.12,49.09 102.01,48.98 102.01,48.64 101.75,48.39 101.75,48.13 102.15,47.73 HDMI1.9
TX0P_A: length 32.7
  TOP w0.089: v1(94.65,74.7) 94.44,74.91 94.44,76.14 CB24.1
  BOTTOM w0.089: L10.1 101.45,53.79 101.71,54.05 101.71,54.43 101.9,54.62 101.9,54.71 R511.1 101.9,55.58 101.9,56.91 101.71,57.1 101.71,65.25 102.45,65.99 102.45,72.78 101.81,73.41 101.55,73.41 101.36,73.6 101.36,73.87 101.17,74.06 100.9,74.06 100.72,74.24 100.72,74.51 100.53,74.7 100.26,74.7 100.07,74.89 100.07,75.15 99.77,75.46 97.87,75.46 97.68,75.27 97.42,75.27 97.23,75.46 96.96,75.46 96.78,75.27 96.51,75.27 96.32,75.46 96.05,75.46 95.87,75.27 95.6,75.27 95.41,75.46 94.7,75.46 94.44,75.2 94.44,74.91 v1(94.65,74.7)
TX0P_A-E: length 5.4
  BOTTOM w0.089: L10.2 101.45,51.61 101.73,51.33 101.73,50.55 101.62,50.44 D56.1 D56.10 101.62,49.09 101.73,48.98 101.73,48.76 101.47,48.5 101.47,48.13 101.15,47.81 HDMI1.7
TX1N_A: length 29.4
  TOP w0.089: v1(96.23,73.76) 96.44,73.97 96.44,76.14 CB25.1
  BOTTOM w0.089: v1(96.23,73.76) 96.44,73.97 96.44,74.22 96.7,74.47 99.34,74.47 101.65,72.17 101.65,66.49 100.23,65.08 100.23,58.06 99.9,57.73 99.9,55.58 R506.1 99.9,54.71 99.9,54.59 100.08,54.41 100.08,54.08 100.35,53.8 L9.4
TX1N_A-E: length 5.4
  BOTTOM w0.089: L9.3 100.35,51.58 100.08,51.31 100.08,50.55 100.19,50.44 D55.5 D55.6 100.19,49.13 100.08,49.02 100.08,48.77 100.31,48.53 100.31,48.03 100.65,47.68 HDMI1.6
TX1P_A: length 29.4
  TOP w0.089: CB26.1 96.72,76.14 96.72,73.97 v1(96.94,73.76)
  BOTTOM w0.089: L9.1 99.55,53.83 99.8,54.08 99.8,54.29 99.62,54.47 99.62,54.71 R510.1 99.62,55.58 99.62,57.85 99.95,58.18 99.95,65.19 100.43,65.67 100.43,65.93 100.61,66.12 100.88,66.12 101.37,66.61 101.37,68.75 101.18,68.94 101.18,69.21 101.37,69.39 101.37,69.66 101.18,69.85 101.18,70.12 101.37,70.3 101.37,70.57 101.18,70.76 101.18,71.02 101.37,71.21 101.37,72.05 99.23,74.19 98.82,74.19 98.63,74.01 98.36,74.01 98.17,74.19 97.91,74.19 97.72,74.01 97.45,74.01 97.27,74.19 96.81,74.19 96.72,74.1 96.72,73.97 v1(96.94,73.76)
TX1P_A-E: length 5.4
  BOTTOM w0.089: L9.2 99.55,51.56 99.8,51.31 99.8,50.55 99.69,50.44 D55.4 D55.7 99.69,49.13 99.8,49.02 99.8,48.65 100.03,48.42 100.03,48.03 99.65,47.65 HDMI1.4
TX2N_A: length 27.3
  TOP w0.089: v1(98.51,72.01) 98.73,72.22 98.73,76.14 CB27.1
  BOTTOM w0.089: v1(98.51,72.01) 98.73,72.22 98.73,72.52 98.98,72.77 99.52,72.77 100.38,71.91 100.38,67.08 99.14,65.84 99.14,58.61 97.61,57.08 97.61,55.58 R508.1 97.66,54.76 97.66,54.66 98.07,54.25 98.07,54.05 98.32,53.8 L8.4
TX2N_A-E: length 5.6
  BOTTOM w0.089: HDMI1.3 99.15,47.74 98.79,48.1 98.79,48.38 98.58,48.59 98.58,48.92 98.69,49.03 D55.9 D55.2 98.69,50.44 98.58,50.55 98.58,50.79 98.06,51.31 98.06,51.38 98.32,51.64 L8.3
TX2P_A: length 27.3
  TOP w0.089: v1(99.23,72.01) 99.01,72.22 99.01,76.14 CB28.1
  BOTTOM w0.089: L8.1 97.52,53.75 97.79,54.03 97.79,54.14 97.38,54.54 97.38,54.66 R505.1 97.33,55.58 97.33,57.2 98.86,58.72 98.86,62.65 98.67,62.84 98.67,63.11 98.86,63.29 98.86,63.56 98.67,63.75 98.67,64.01 98.86,64.2 98.86,65.95 99.3,66.39 99.3,66.66 99.48,66.85 99.75,66.85 100.1,67.2 100.1,68.88 99.91,69.07 99.91,69.33 100.1,69.52 100.1,69.79 99.91,69.98 99.91,70.24 100.1,70.43 100.1,70.7 99.91,70.89 99.91,71.15 100.1,71.34 100.1,71.79 99.4,72.49 99.1,72.49 99.01,72.4 99.01,72.22 v1(99.23,72.01)
TX2P_A-E: length 5.6
  BOTTOM w0.089: L8.2 97.52,51.64 97.78,51.38 97.78,51.19 98.3,50.67 98.3,50.55 98.19,50.44 D55.1 D55.10 98.19,49.01 98.3,48.9 98.3,48.47 98.51,48.26 98.51,48.1 98.15,47.74 HDMI1.1
TX_AVDD_A: length 1.8
  TOP w0.203: U66.28 v1(96.69,81.15) ; U66.22 v1(94.29,81.15)
TX_CEC_A: length 65.9
  TOP w0.203: U66.62 v1(93.09,90.63)
  BOTTOM w0.254: v1(93.09,90.63) 92.91,90.81 90.58,90.81 88.21,88.44 88.21,87.1 86.39,85.28 86.39,79.3 87.41,78.28 101.02,78.28 105.23,74.07 105.23,58.3 105.86,57.66 105.86,54.17 104.74,53.05 104.74,50.66 104.92,50.48 D57.6 D57.5 104.92,48.72 104.15,47.95 HDMI1.13
TX_HPD_A: length 49.4
  TOP w0.107: U66.39 99.8,85.33 99.8,85.33 100.32,85.33 v1(100.9,84.75)
  BOTTOM w0.107: v1(100.9,84.75) 102.98,84.75 105.66,82.07 107.11,82.07 112.51,76.66 112.51,61.89 111.05,60.43 111.05,57.78 108.41,55.14 108.41,52.15 108.2,51.94 R519.2 107.85,51.37 106.92,50.44 D57.10 D57.1 106.92,48.94 107.28,48.58 107.28,48.1 107.15,47.97 HDMI1.19
TX_PVDD_A: length 5.4
  TOP w0.203: U66.18 92.69,81.49 92.45,81.25 v1(92.45,81.15)
  BOTTOM w0.508: FB33.1 C311.1 92.45,80.65 v1(92.45,81.15) 92.45,81.38 92.9,81.83 C312.1
TX_RSEN_A: length 48.1
  TOP w0.203: U66.6 v1(90.58,86.93)
  TOP w0.254: v1(103.17,59.05) v1(104.43,59.05)
  IN3 w0.254: v1(90.58,86.93) 89.5,86.93 89.05,86.49 89.05,78.56 v1(89.92,77.7)
  BOTTOM w0.254: R526.1 104.52,58.52 104.52,58.97 v1(104.43,59.05) 104.84,59.47 104.84,73.91 100.86,77.9 90.11,77.9 v1(89.92,77.7) ; R527.1 103.17,58.47 v1(103.17,59.05) ; R529.2 91.12,86.25 C296.1 90.58,86.96 v1(90.58,86.93)
TX_SCL_A: length 61
  TOP w0.107: U66.2 90.81,88.53 90.45,88.9 v1(90.07,88.9)
  BOTTOM w0.107: v1(90.07,88.9) 89.43,88.9 88.69,88.16 88.69,86.25 87.91,85.47 87.91,79.48 88.55,78.84 101.85,78.84 105.71,74.98 105.71,58.5 106.34,57.86 106.34,53.59 105.74,52.98 R530.2 105.53,52.91 105.22,52.6 105.22,50.81 105.42,50.61 D57.7 D57.4 105.42,48.39 105.15,48.13 HDMI1.15
TX_SDA_A: length 61
  TOP w0.107: v1(90.45,88.27) 90.58,88.13 U66.3
  BOTTOM w0.107: v1(90.45,88.27) 89.56,88.27 arc(89.44,88.24) 89.34,88.18 89.24,88.07 89.19,88.02 arc(89.13,87.93) 89.1,87.81 89.1,87.6 arc(89.18,87.42) 89.36,87.35 89.46,87.35 arc(89.6,87.29) 89.66,87.14 89.66,86.86 arc(89.6,86.7) 89.43,86.63 89.28,86.63 arc(89.16,86.58) 89.1,86.45 89.1,86.06 88.32,85.27 88.32,79.65 88.72,79.25 102.02,79.25 106.12,75.15 106.12,58.67 106.76,58.03 R531.2 107.04,52.91 107.26,52.68 107.26,51.37 106.42,50.53 D57.9 D57.2 106.42,48.51 105.65,47.74 HDMI1.16
TXCN_A: length 38
  TOP w0.089: v1(91.66,74.7) 91.87,74.91 91.87,76.14 CB21.1
  BOTTOM w0.089: L11.4 104.16,53.79 103.9,54.05 103.9,54.15 104,54.26 104.09,54.26 104.34,54.51 104.34,54.71 R514.1 104.34,55.58 104.34,56.58 103.99,56.94 103.99,57.02 104.39,57.43 R526.2 103.96,57.86 103.96,73.52 100.47,77.01 93.29,77.01 91.87,75.59 91.87,74.91 v1(91.66,74.7)
TXCN_A-E: length 5.5
  BOTTOM w0.089: HDMI1.12 103.65,47.78 103.28,48.15 103.28,48.25 103.51,48.48 103.51,49.02 103.62,49.13 D56.6 D56.5 103.62,50.44 103.51,50.55 103.51,50.67 103.91,51.08 103.91,51.36 104.16,51.61 L11.3
TXCP_A: length 38.1
  TOP w0.089: v1(92.37,74.7) 92.15,74.91 92.15,76.14 CB22.1
  BOTTOM w0.089: v1(92.37,74.7) 92.15,74.91 92.15,75.47 93.41,76.73 95.03,76.73 95.22,76.55 95.48,76.55 95.67,76.73 95.94,76.73 96.13,76.55 96.39,76.55 96.58,76.73 96.85,76.73 97.04,76.55 97.3,76.55 97.49,76.73 100.36,76.73 101.13,75.96 101.13,75.69 101.32,75.5 101.59,75.5 101.77,75.31 101.77,75.05 101.96,74.86 102.23,74.86 102.42,74.67 102.42,74.41 102.61,74.22 102.87,74.22 103.68,73.41 103.68,57.86 R527.2 103.71,56.97 103.71,56.82 104.06,56.46 104.06,55.58 R513.1 104.06,54.71 104.06,54.62 103.97,54.54 103.88,54.54 103.62,54.27 103.62,54.05 103.36,53.79 L11.1
TXCP_A-E: length 5.5
  BOTTOM w0.089: HDMI1.10 102.65,47.79 103,48.13 103,48.36 103.23,48.59 103.23,49.02 103.12,49.13 D56.7 D56.4 103.12,50.44 103.23,50.55 103.23,50.79 103.63,51.2 103.63,51.34 103.36,51.61 L11.2
TXNE_UP: length 1.5
  TOP w0.102: CA20.2 80.75,72.22 80.75,71.37 80.82,71.3 U20.33
TXPE_UP: length 1.6
  TOP w0.102: U20.34 80.42,71.28 80.49,71.35 80.49,72.15 CA21.2
TYPE-C0_CC1-C: length 6.8
  BOTTOM w0.254: USB1.2 60.65,46.17 62.07,47.59 D11.5 D11.6 62.07,50.58 61.85,50.8 61.85,51.46 R1512.2
TYPE-C0_CC2-C: length 6.2
  BOTTOM w0.254: USB1.4 62.65,47.1 62.57,47.19 D11.4 D11.7 62.57,50.66 62.38,50.85 62.38,51.61 R1513.2
TYPEC0_DM-E: length 8.9
  BOTTOM w0.102: USB1.3 63.42,43.87 63.53,43.97 63.53,47.5 63.69,47.67 63.69,49.11 63.57,49.23 D11.2 D11.9 63.57,50.5 63.7,50.64 63.7,50.8 63.88,50.98 63.88,51.08 63.61,51.35 L7.2
TYPEC0_DP-E: length 8.9
  BOTTOM w0.102: USB1.5 63.88,43.87 63.78,43.97 63.78,47.4 63.95,47.56 63.95,49.11 64.07,49.23 D11.1 D11.10 64.07,50.51 63.96,50.62 63.96,50.7 64.14,50.88 64.14,51.05 64.41,51.33 L7.3
UART0_RX_OOB_3V3: length 16.7
  BOTTOM w0.107: OOB1.5 153.16,94.2 151.09,96.27 151.09,100.12 148.47,102.74 145.69,102.74 145.44,103 R6.1 RZ39.2
UART0_TX_OOB_3V3: length 16.8
  BOTTOM w0.107: OOB1.6 153.16,93.2 150.68,95.68 150.68,99.79 148.87,101.6 145.69,101.6 145.44,101.85 R4.1 RZ36.2
UART1_CTS: length 1.4
  TOP w0.107: J1.H54 v1(100.4,129.02)
  BOTTOM w0.107: v1(100.4,129.02) 100.4,129.74 TP11.1
UART1_RXD: length 70.7
  TOP w0.107: J1.K54 v1(100.4,132.02) ; RZ148.1 v1(65.66,173.99)
  IN1 w0.124: v1(100.4,132.02) 100.4,132.44 97.64,135.2 96.95,135.2 94.2,137.95 v1(77.88,137.95)
  IN3 w0.124: v1(65.66,173.99) 65.66,168.17 68.1,165.72 68.1,151.66 77.85,141.91 77.85,137.97 v1(77.88,137.95)
  BOTTOM w0.107: v1(65.66,173.99) 66.16,173.99 66.78,174.6 66.78,176.02 RZ688.1
UART1_TXD: length 68.3
  TOP w0.107: J1.K53 v1(99.5,132.02)
  IN1 w0.124: v1(99.5,132.02) 99.5,132.73 97.46,134.77 96.77,134.77 94.13,137.41 v1(78.36,137.41)
  IN3 w0.124: v1(78.36,137.41) 78.36,142.01 68.53,151.84 68.53,165.9 66.17,168.27 66.17,174.88 v1(65.66,175.39)
  BOTTOM w0.107: RZ145.1 v1(65.66,175.39)
UART2_CTS: length 13.6
  TOP w0.107: J1.A57 103.3,117.46 103.77,117.28 106.81,116.61 113.25,116.61 113.79,117.14 RZ25.1
UART2_RTS: length 8.2
  TOP w0.107: J1.G58 v1(103.8,127.52)
  BOTTOM w0.107: v1(103.8,127.52) 104.39,128.11 110.99,128.11 RZ171.1
UART2_RX_OOB_3V3: length 16.4
  BOTTOM w0.107: OOB1.3 153.16,96.2 151.92,97.44 151.92,100.46 147.27,105.1 145.62,105.1 145.44,105.28 R10.1 RZ47.2
UART2_RXD: length 51.2
  TOP w0.107: J1.C56 v1(102,121.52)
  IN3 w0.124: v1(128.47,119.7) 127.92,119.14 127.92,116.94 134.49,110.37 134.49,105.98 v1(137.06,103.4)
  BOTTOM w0.107: RZ38.1 137.67,103.4 v1(137.06,103.4) 136.4,103.4 R9.1 ; v1(128.47,119.7) 127.82,119.04 111.17,119.04 110.87,119.34 106.86,119.34 106.31,118.79 103.59,118.79 102,120.37 v1(102,121.52)
UART2_RXD_3V3: length 1.8
  BOTTOM w0.107: U85.9 142.52,103.76 142.9,103.38 RZ39.1
UART2_TX_OOB_3V3: length 16.5
  BOTTOM w0.107: RZ41.2 R8.1 145.44,104.27 145.76,103.95 147.84,103.95 151.51,100.29 151.51,96.86 153.16,95.2 OOB1.4
UART2_TXD: length 50.3
  TOP w0.107: J1.C58 v1(103.8,121.52)
  IN3 w0.124: v1(137.06,102.23) 134.06,105.24 134.06,110.19 127.48,116.76 127.48,119.37 v1(127.81,119.7)
  BOTTOM w0.107: RZ35.1 v1(137.06,102.23) R5.1 ; v1(127.81,119.7) 127.57,119.46 111.34,119.46 111.04,119.75 106.69,119.75 106.14,119.2 104.17,119.2 103.56,119.81 103.56,121.28 v1(103.8,121.52)
UART2_TXD_3V3: length 2.2
  BOTTOM w0.107: U85.10 142.28,103.36 143.28,102.36 RZ36.1
UART3_RXD: length 51.9
  TOP w0.107: J1.K60 v1(105.8,132.02)
  IN3 w0.124: v1(127.28,128.65) 127.28,124.36 131.21,120.42 131.21,114.85 135.35,110.72 135.35,107.43 v1(137.06,105.71)
  BOTTOM w0.107: v1(105.8,132.02) 106.37,131.44 121.2,131.44 124.01,128.63 127.26,128.63 v1(127.28,128.65) ; RZ46.1 137.11,105.66 v1(137.06,105.71) 137.01,105.66 R11.1
UART3_TXD: length 52
  TOP w0.107: J1.H62 v1(107.6,129.02)
  IN3 w0.124: v1(126.77,128.14) 126.77,124.26 130.78,120.24 130.78,114.68 134.92,110.55 134.92,106.66 v1(137.06,104.52)
  BOTTOM w0.107: R7.1 v1(137.06,104.52) RZ40.1 ; v1(107.6,129.02) 107.6,130.68 107.95,131.03 121.03,131.03 123.92,128.14 v1(126.77,128.14)
UART5_CTS: length 45.2
  TOP w0.107: J1.H57 v1(103.1,129.02)
  BOTTOM w0.107: v1(103.1,129.02) 103.1,129.77 103.38,130.05 103.38,132.08 103.89,132.59 111.67,132.59 112.4,131.86 121.37,131.86 124.07,129.16 130.05,129.16 130.56,129.67 131.83,129.67 132.94,128.55 139.86,128.55 140.49,129.18 WIFI1.34
UART5_RTS: length 41
  TOP w0.107: J1.K58 v1(104,132.02)
  IN1 w0.124: v1(104,132.02) 104,132.58 105.77,134.34 119.09,134.34 119.99,133.44 138.31,133.44 139.67,132.09 v1(140.99,132.09)
  BOTTOM w0.107: WIFI1.36 v1(140.99,132.09)
UART5_RXD: length 37.4
  TOP w0.107: J1.H58 v1(104,129.02)
  IN1 w0.124: v1(104,129.02) 106.16,129.02 106.68,129.54 112.27,129.54 113.31,128.5 122.66,128.5 123.57,129.41 130.05,129.41 131.44,130.81 136.22,130.81 v1(137.49,132.08)
  BOTTOM w0.107: WIFI1.22 v1(137.49,132.08)
UART5_TXD: length 42.9
  TOP w0.107: J1.J58 v1(103.8,130.52)
  IN1 w0.124: v1(103.8,130.52) 103.8,131.02 103.5,131.32 103.5,132.72 105.56,134.77 119.27,134.77 120.17,133.87 138.59,133.87 139.88,132.59 v1(139.99,132.59)
  BOTTOM w0.107: WIFI1.32 v1(139.99,132.59)
UART1812_RX: length 44.9
  BOTTOM w0.107: U67.B9 53.96,99.82 53.56,100.22 51.38,100.22 50.75,99.59 50.75,96.24 R589.1 50.75,95.94 50.75,94.56 49.96,93.77 49.96,84.45 47.45,81.94 37.39,81.94 36.78,82.55 28.07,82.55 J11.4
UART1812_TX: length 42.3
  BOTTOM w0.107: U67.A9 51.56,99.82 51.26,99.52 51.26,94.18 50.37,93.29 50.37,84.28 47.62,81.53 42.82,81.53 42.7,81.41 RZ193.2 R605.1 41,81.43 37.19,81.43 36.5,82.12 29.57,82.12 28.83,81.38 J11.3
UART_RXD: length 5.8
  BOTTOM w0.107: RZU47.2 34.72,74.42 31.37,74.42 J7.2
UART_TXD: length 2.6
  BOTTOM w0.107: J7.1 32.41,72.92 RZU46.2
UFS0_REF_CLK: length 110.8
  TOP w0.107: SSD2.56 151.31,113.25 v1(151.21,113.36) ; J1.A6 v1(54.2,118.52)
  BOTTOM w0.107: v1(151.21,113.36) 149.92,112.07 143.75,112.07 140.74,111.08 138.8,109.45 137.63,109.42 137.25,109.42 135.18,109.38 134.07,109.89 123.86,109.89 119.03,105.06 112.86,105.06 111.22,103.41 105.78,103.41 102.46,106.74 98.44,106.74 95.09,110.09 85.52,110.09 79.13,112.59 78.02,112.88 73.5,112.88 72.79,113.03 56.21,113.03 55.86,113.37 55.86,115.13 54.2,116.79 v1(54.2,118.52)
UFS0_RST_N: length 116
  TOP w0.107: v1(151.79,113.67) 151.81,113.64 SSD2.58 ; J1.C6 v1(54.2,121.52)
  BOTTOM w0.107: v1(54.2,121.52) 53.75,121.07 53.75,116.66 55.45,114.96 55.45,113.2 56.04,112.62 72.75,112.62 73.46,112.47 77.92,112.47 79.02,112.18 85.41,109.68 94.92,109.68 98.27,106.32 102.29,106.32 105.61,103 111.39,103 113.03,104.65 119.2,104.65 124.03,109.47 133.93,109.47 135.04,108.96 137.26,109.01 137.64,109.01 138.95,109.04 140.95,110.71 143.82,111.66 150.09,111.66 151.79,113.36 v1(151.79,113.67)
UIM1_CLK: length 29
  BOTTOM w0.107: JSIM1.C3 124.46,181.7 C120.2 124.9,181.7 125.12,181.48 125.12,180.19 125.48,179.83 126.83,179.83 128.28,181.28 142.09,181.28 144.23,183.42 NGFF1.32
UIM1_DATA: length 25.7
  BOTTOM w0.107: NGFF1.34 144.15,183.92 141.92,181.7 125.73,181.7 C118.2 125.73,181.7 JSIM1.C7
UIM1_DET: length 3.4
  BOTTOM w0.107: NGFF1.66 146.43,191.92 R228.1 R225.2
UIM1_PWR: length 43.2
  TOP w0.508: v1(147.46,184.42) 146.81,183.77 144.27,183.77 141.99,181.48 120.82,181.48 v1(119.42,180.09)
  IN3 w0.508: v1(147.46,184.42) 146.3,185.58 146.3,190.25 145.8,190.75 v1(144.78,190.75)
  BOTTOM w0.305: NGFF1.36 v1(147.46,184.42)
  BOTTOM w0.508: R225.1 v1(144.78,190.75) ; JSIM1.C1 119.38,181.9 CA120.1 C119.2 v1(119.42,180.09)
UIM1_RESET: length 32
  BOTTOM w0.107: JSIM1.C2 121.92,181.7 C121.2 122.45,181.7 122.56,181.59 122.56,179.71 122.84,179.42 127,179.42 128.45,180.87 142.27,180.87 144.31,182.92 NGFF1.30
UIM1_VPP: length 1.8
  BOTTOM w0.508: JSIM1.C6 123.19,181.7 C117.2
UIM2_CLK: length 14
  TOP w0.107: v1(139.01,182.37) 139.06,182.43 C125.2 139.48,183.17 139.7,183.39 139.7,185.29 140,185.59 145.17,185.59 146,186.42 v1(147.45,186.42)
  BOTTOM w0.107: NGFF1.44 v1(147.45,186.42) ; v1(139.01,182.37) JSIM2.C3
UIM2_DATA: length 12.2
  TOP w0.107: v1(140.28,182.44) 140.34,182.5 C124.2 140.75,183.17 141.1,183.51 141.1,185.08 141.22,185.2 145.33,185.2 146.05,185.93 147.06,185.93 v1(147.07,185.92)
  BOTTOM w0.107: NGFF1.42 v1(147.07,185.92) ; JSIM2.C7 v1(140.28,182.44)
UIM2_DET: length 5.1
  BOTTOM w0.107: R224.2 145.44,185.75 R227.1 146.33,185.65 146.56,185.42 NGFF1.40
UIM2_PWR: length 20.6
  TOP w0.508: v1(133.93,182.37) 133.87,182.43 CA4.1 C128.2 135.25,183.17 135.76,183.68 135.76,185.17 137.16,186.56 144.76,186.56 145.78,187.58 147.29,187.58 v1(147.45,187.42)
  BOTTOM w0.107: JSIM2.C1 v1(133.93,182.37)
  BOTTOM w0.305: R224.1 147.41,187.45 v1(147.45,187.42) NGFF1.48
UIM2_RESET: length 16.8
  TOP w0.107: v1(147.07,186.92) 145.95,186.92 145.01,185.98 137.84,185.98 137.16,185.29 137.16,183.39 136.94,183.17 C126.2 136.54,182.44 v1(136.47,182.37)
  BOTTOM w0.107: NGFF1.46 v1(147.07,186.92) ; v1(136.47,182.37) JSIM2.C2
UIM2_VPP: length 1.9
  TOP w0.508: v1(137.74,182.37) 137.79,182.43 C123.2
  BOTTOM w0.508: JSIM2.C6 v1(137.74,182.37)
UPE_CLKN: length 4.4
  TOP w0.114: U70.72 48.19,67.46 48.12,67.53 45.53,67.53 45.43,67.63 44.87,67.63 RZ83.2
UPE_CLKP: length 4.4
  TOP w0.114: RZ80.2 44.87,67.88 45.53,67.88 45.63,67.78 48.12,67.78 48.2,67.86 U70.71
UPE_CLKREQN: length 6.7
  TOP w0.107: v1(73.91,105.34) 73.91,106.15 73.81,106.25 RZU21.1 R562.1 R561.2
  BOTTOM w0.107: v1(73.91,105.34) 73.84,105.34 73.16,104.66 U67.AF3
UPE_RXN0: length 4.7
  TOP w0.114: U70.47 56.96,70.74 57.03,70.81 57.03,74.32 CM56.1
UPE_RXN1: length 6.9
  TOP w0.114: CM50.1 53.43,76.48 53.43,70.79 53.36,70.71 U70.56
UPE_RXP0: length 4.7
  TOP w0.114: U70.46 57.36,70.74 57.29,70.81 57.29,74.34 CM57.1
UPE_RXP1: length 6.8
  TOP w0.114: U70.55 53.76,70.71 53.69,70.79 53.69,76.51 CM51.1
